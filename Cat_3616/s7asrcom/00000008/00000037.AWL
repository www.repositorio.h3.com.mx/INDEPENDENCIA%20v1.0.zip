	TYPE UDT 120
	STRUCT
	ObjNo : INT ;	//ObjNo
	Status : WORD ;	//Status
	Value : REAL ;	//Value
	TimeStamp : INT ;//TimeStamp
	END_STRUCT ;
	END_TYPE


	TYPE UDT 121
	STRUCT
	ObjNo : INT ;	//ObjNo
	Value : REAL ;	//Value
	TimeStamp : INT ;	//TimeStamp
	END_STRUCT ;
	END_TYPE

	TYPE UDT 122
	STRUCT
	ObjNo : INT ;	//ObjNo
	RelNo : INT ;	//RelNo
	Limit : REAL ;	//Limit
	TimeStamp : INT ;	//TimeStamp
	END_STRUCT ;
	END_TYPE


	TYPE UDT 123
	STRUCT
	ObjNo : INT ;	//ObjNo
	Status : WORD ;	//Status
	END_STRUCT ;
	END_TYPE


	TYPE UDT 124
	STRUCT
	ObjNo : INT ;	//ObjNo
	Value : REAL ;	//Value
	END_STRUCT ;
	END_TYPE


	TYPE UDT 125
	STRUCT
	Station : INT ;	//Station
	ObjNo : INT ;	//ObjNo
	Value : REAL ;	//Value
	TimeStamp : INT ;	//TimeStamp
	END_STRUCT ;
	END_TYPE


	TYPE UDT 126
	STRUCT
	Station : INT ;	//Station
	ObjNo : INT ;	//ObjNo
	Str_DB : INT ;	//Str_DB
	Str_Ptr : DWORD ;	//Str_Ptr
	END_STRUCT ;
	END_TYPE


	DATA_BLOCK DB 194
	TITLE =
	AUTHOR : AV_ET
	FAMILY : AbvSpu
	Name : OBJ_DB
	VERSION : 0.0
	STRUCT
	_010101 : int := 00001;	// 010101 ( 00001 )
	_010102 : int := 00002;	// 010102 ( 00002 )
	_010103 : int := 00003;	// 010103 ( 00003 )
	_010104 : int := 00004;	// 010104 ( 00004 )
	_010105 : int := 00005;	// 010105 ( 00005 )
	_010106 : int := 00006;	// 010106 ( 00006 )
	_010107 : int := 00007;	// 010107 ( 00007 )
	_010108 : int := 00008;	// 010108 ( 00008 )
	_010109 : int := 00009;	// 010109 ( 00009 )
	_010110 : int := 00010;	// 010110 ( 00010 )
	_010111 : int := 00011;	// 010111 ( 00011 )
	_010112 : int := 00012;	// 010112 ( 00012 )
	_010113 : int := 00013;	// 010113 ( 00013 )
	_010114 : int := 00014;	// 010114 ( 00014 )
	_010115 : int := 00015;	// 010115 ( 00015 )
	_010116 : int := 00016;	// 010116 ( 00016 )
	_010117 : int := 00017;	// 010117 ( 00017 )
	_010118 : int := 00018;	// 010118 ( 00018 )
	_010119 : int := 00019;	// 010119 ( 00019 )
	_010120 : int := 00020;	// 010120 ( 00020 )
	_010121 : int := 00021;	// 010121 ( 00021 )
	_010122 : int := 00022;	// 010122 ( 00022 )
	_010123 : int := 00023;	// 010123 ( 00023 )
	_010124 : int := 00024;	// 010124 ( 00024 )
	_010125 : int := 00025;	// 010125 ( 00025 )
	_010126 : int := 00026;	// 010126 ( 00026 )
	_010127 : int := 00027;	// 010127 ( 00027 )
	_010128 : int := 00028;	// 010128 ( 00028 )
	_010129 : int := 00029;	// 010129 ( 00029 )
	_010130 : int := 00030;	// 010130 ( 00030 )
	_010131 : int := 00031;	// 010131 ( 00031 )
	_010132 : int := 00032;	// 010132 ( 00032 )
	_010133 : int := 00033;	// 010133 ( 00033 )
	_010134 : int := 02500;	// 010134 ( 02500 )
	_010135 : int := 02501;	// 010135 ( 02501 )
	_010136 : int := 02502;	// 010136 ( 02502 )
	_010137 : int := 02503;	// 010137 ( 02503 )
	_010138 : int := 02504;	// 010138 ( 02504 )
	_010139 : int := 02505;	// 010139 ( 02505 )
	_010140 : int := 02506;	// 010140 ( 02506 )
	_010141 : int := 02507;	// 010141 ( 02507 )
	_010142 : int := 02508;	// 010142 ( 02508 )
	_010143 : int := 02509;	// 010143 ( 02509 )
	_010144 : int := 02510;	// 010144 ( 02510 )
	_010145 : int := 02511;	// 010145 ( 02511 )
	_010146 : int := 02512;	// 010146 ( 02512 )
	_010147 : int := 02513;	// 010147 ( 02513 )
	_010148 : int := 02514;	// 010148 ( 02514 )
	_010149 : int := 02515;	// 010149 ( 02515 )
	_010150 : int := 02516;	// 010150 ( 02516 )
	_010151 : int := 02517;	// 010151 ( 02517 )
	_010152 : int := 02518;	// 010152 ( 02518 )
	_010153 : int := 02519;	// 010153 ( 02519 )
	_010154 : int := 02520;	// 010154 ( 02520 )
	_010155 : int := 02521;	// 010155 ( 02521 )
	_010155D : int := 02522;	// 010155D ( 02522 )
	_010156 : int := 02523;	// 010156 ( 02523 )
	_010156D : int := 02524;	// 010156D ( 02524 )
	_010157 : int := 02525;	// 010157 ( 02525 )
	_010157D : int := 02526;	// 010157D ( 02526 )
	_010158 : int := 02527;	// 010158 ( 02527 )
	_010158D : int := 02528;	// 010158D ( 02528 )
	_010159 : int := 02529;	// 010159 ( 02529 )
	_010159D : int := 02530;	// 010159D ( 02530 )
	_010160 : int := 02531;	// 010160 ( 02531 )
	_010160D : int := 02532;	// 010160D ( 02532 )
	_010161 : int := 02533;	// 010161 ( 02533 )
	_010161D : int := 02534;	// 010161D ( 02534 )
	_010162 : int := 02535;	// 010162 ( 02535 )
	_010162D : int := 02536;	// 010162D ( 02536 )
	_010163 : int := 02537;	// 010163 ( 02537 )
	_010163D : int := 02538;	// 010163D ( 02538 )
	_010164 : int := 02539;	// 010164 ( 02539 )
	_010164D : int := 02540;	// 010164D ( 02540 )
	_010165 : int := 02541;	// 010165 ( 02541 )
	_010165D : int := 02542;	// 010165D ( 02542 )
	_010166 : int := 02543;	// 010166 ( 02543 )
	_010166D : int := 02544;	// 010166D ( 02544 )
	_010167 : int := 02545;	// 010167 ( 02545 )
	_010167D : int := 02546;	// 010167D ( 02546 )
	_010168 : int := 02547;	// 010168 ( 02547 )
	_010168D : int := 02548;	// 010168D ( 02548 )
	_010169 : int := 02549;	// 010169 ( 02549 )
	_010169D : int := 02550;	// 010169D ( 02550 )
	_010170 : int := 02551;	// 010170 ( 02551 )
	_010170D : int := 02552;	// 010170D ( 02552 )
	_010171 : int := 02553;	// 010171 ( 02553 )
	_010172 : int := 02554;	// 010172 ( 02554 )
	_010173 : int := 02555;	// 010173 ( 02555 )
	_010174 : int := 02556;	// 010174 ( 02556 )
	_010175A : int := 00034;	// 010175A ( 00034 )
	_010175C : int := 05000;	// 010175C ( 05000 )
	_010175S : int := 05001;	// 010175S ( 05001 )
	_010176 : int := 00035;	// 010176 ( 00035 )
	_010177 : int := 00036;	// 010177 ( 00036 )
	_010178 : int := 00037;	// 010178 ( 00037 )
	_010179 : int := 00038;	// 010179 ( 00038 )
	_010180 : int := 00039;	// 010180 ( 00039 )
	_010201 : int := 00040;	// 010201 ( 00040 )
	_010202 : int := 00041;	// 010202 ( 00041 )
	_010203 : int := 00042;	// 010203 ( 00042 )
	_010204 : int := 00043;	// 010204 ( 00043 )
	_010205 : int := 00044;	// 010205 ( 00044 )
	_010206 : int := 00045;	// 010206 ( 00045 )
	_010207 : int := 00046;	// 010207 ( 00046 )
	_010208 : int := 00047;	// 010208 ( 00047 )
	_010209 : int := 00048;	// 010209 ( 00048 )
	_010210 : int := 00049;	// 010210 ( 00049 )
	_010211 : int := 00050;	// 010211 ( 00050 )
	_010212 : int := 00051;	// 010212 ( 00051 )
	_010213 : int := 00052;	// 010213 ( 00052 )
	_010214 : int := 00053;	// 010214 ( 00053 )
	_010215 : int := 00054;	// 010215 ( 00054 )
	_010216 : int := 00055;	// 010216 ( 00055 )
	_010217 : int := 00056;	// 010217 ( 00056 )
	_010218 : int := 00057;	// 010218 ( 00057 )
	_010219 : int := 00058;	// 010219 ( 00058 )
	_010220 : int := 00059;	// 010220 ( 00059 )
	_010221 : int := 00060;	// 010221 ( 00060 )
	_010222 : int := 00061;	// 010222 ( 00061 )
	_010223 : int := 00062;	// 010223 ( 00062 )
	_010224 : int := 00063;	// 010224 ( 00063 )
	_010225 : int := 00064;	// 010225 ( 00064 )
	_010226 : int := 00065;	// 010226 ( 00065 )
	_010227 : int := 00066;	// 010227 ( 00066 )
	_010228 : int := 00067;	// 010228 ( 00067 )
	_010229 : int := 00068;	// 010229 ( 00068 )
	_010230 : int := 00069;	// 010230 ( 00069 )
	_010231 : int := 00070;	// 010231 ( 00070 )
	_010232 : int := 00071;	// 010232 ( 00071 )
	_010233 : int := 00072;	// 010233 ( 00072 )
	_010234 : int := 02557;	// 010234 ( 02557 )
	_010235 : int := 02558;	// 010235 ( 02558 )
	_010236 : int := 02559;	// 010236 ( 02559 )
	_010237 : int := 02560;	// 010237 ( 02560 )
	_010238 : int := 02561;	// 010238 ( 02561 )
	_010239 : int := 02562;	// 010239 ( 02562 )
	_010240 : int := 02563;	// 010240 ( 02563 )
	_010241 : int := 02564;	// 010241 ( 02564 )
	_010242 : int := 02565;	// 010242 ( 02565 )
	_010243 : int := 02566;	// 010243 ( 02566 )
	_010244 : int := 02567;	// 010244 ( 02567 )
	_010245 : int := 02568;	// 010245 ( 02568 )
	_010246 : int := 02569;	// 010246 ( 02569 )
	_010247 : int := 02570;	// 010247 ( 02570 )
	_010248 : int := 02571;	// 010248 ( 02571 )
	_010249 : int := 02572;	// 010249 ( 02572 )
	_010250 : int := 02573;	// 010250 ( 02573 )
	_010251 : int := 02574;	// 010251 ( 02574 )
	_010252 : int := 02575;	// 010252 ( 02575 )
	_010253 : int := 02576;	// 010253 ( 02576 )
	_010254 : int := 02577;	// 010254 ( 02577 )
	_010255 : int := 02578;	// 010255 ( 02578 )
	_010255D : int := 02579;	// 010255D ( 02579 )
	_010256 : int := 02580;	// 010256 ( 02580 )
	_010256D : int := 02581;	// 010256D ( 02581 )
	_010257 : int := 02582;	// 010257 ( 02582 )
	_010257D : int := 02583;	// 010257D ( 02583 )
	_010258 : int := 02584;	// 010258 ( 02584 )
	_010258D : int := 02585;	// 010258D ( 02585 )
	_010259 : int := 02586;	// 010259 ( 02586 )
	_010259D : int := 02587;	// 010259D ( 02587 )
	_010260 : int := 02588;	// 010260 ( 02588 )
	_010260D : int := 02589;	// 010260D ( 02589 )
	_010261 : int := 02590;	// 010261 ( 02590 )
	_010261D : int := 02591;	// 010261D ( 02591 )
	_010262 : int := 02592;	// 010262 ( 02592 )
	_010262D : int := 02593;	// 010262D ( 02593 )
	_010263 : int := 02594;	// 010263 ( 02594 )
	_010263D : int := 02595;	// 010263D ( 02595 )
	_010264 : int := 02596;	// 010264 ( 02596 )
	_010264D : int := 02597;	// 010264D ( 02597 )
	_010265 : int := 02598;	// 010265 ( 02598 )
	_010265D : int := 02599;	// 010265D ( 02599 )
	_010266 : int := 02600;	// 010266 ( 02600 )
	_010266D : int := 02601;	// 010266D ( 02601 )
	_010267 : int := 02602;	// 010267 ( 02602 )
	_010267D : int := 02603;	// 010267D ( 02603 )
	_010268 : int := 02604;	// 010268 ( 02604 )
	_010268D : int := 02605;	// 010268D ( 02605 )
	_010269 : int := 02606;	// 010269 ( 02606 )
	_010269D : int := 02607;	// 010269D ( 02607 )
	_010270 : int := 02608;	// 010270 ( 02608 )
	_010270D : int := 02609;	// 010270D ( 02609 )
	_010271 : int := 02610;	// 010271 ( 02610 )
	_010272 : int := 02611;	// 010272 ( 02611 )
	_010273 : int := 02612;	// 010273 ( 02612 )
	_010274 : int := 02613;	// 010274 ( 02613 )
	_010275A : int := 00073;	// 010275A ( 00073 )
	_010275C : int := 05002;	// 010275C ( 05002 )
	_010275S : int := 05003;	// 010275S ( 05003 )
	_010276 : int := 00074;	// 010276 ( 00074 )
	_010277 : int := 00075;	// 010277 ( 00075 )
	_010278 : int := 00076;	// 010278 ( 00076 )
	_010279 : int := 00077;	// 010279 ( 00077 )
	_010280 : int := 00078;	// 010280 ( 00078 )
	_020101 : int := 00079;	// 020101 ( 00079 )
	_020102 : int := 00080;	// 020102 ( 00080 )
	_020103 : int := 00081;	// 020103 ( 00081 )
	_020104 : int := 00082;	// 020104 ( 00082 )
	_020105 : int := 00083;	// 020105 ( 00083 )
	_020106 : int := 00084;	// 020106 ( 00084 )
	_020107 : int := 00085;	// 020107 ( 00085 )
	_020108 : int := 00086;	// 020108 ( 00086 )
	_020109 : int := 00087;	// 020109 ( 00087 )
	_020201 : int := 00088;	// 020201 ( 00088 )
	_020202 : int := 00089;	// 020202 ( 00089 )
	_020203 : int := 00090;	// 020203 ( 00090 )
	_020204 : int := 00091;	// 020204 ( 00091 )
	_020205 : int := 00092;	// 020205 ( 00092 )
	_020206 : int := 00093;	// 020206 ( 00093 )
	_020207 : int := 00094;	// 020207 ( 00094 )
	_020208 : int := 00095;	// 020208 ( 00095 )
	_020209 : int := 00096;	// 020209 ( 00096 )
	_020301 : int := 00097;	// 020301 ( 00097 )
	_020302 : int := 00098;	// 020302 ( 00098 )
	_020303 : int := 00099;	// 020303 ( 00099 )
	_020304 : int := 00100;	// 020304 ( 00100 )
	_020305 : int := 00101;	// 020305 ( 00101 )
	_020306 : int := 00102;	// 020306 ( 00102 )
	_020307 : int := 00103;	// 020307 ( 00103 )
	_020308 : int := 00104;	// 020308 ( 00104 )
	_020309 : int := 00105;	// 020309 ( 00105 )
	_030001 : int := 00106;	// 030001 ( 00106 )
	_030002 : int := 00107;	// 030002 ( 00107 )
	_030003 : int := 00108;	// 030003 ( 00108 )
	_030004 : int := 00109;	// 030004 ( 00109 )
	_030005 : int := 00110;	// 030005 ( 00110 )
	_030006 : int := 00111;	// 030006 ( 00111 )
	_030007 : int := 00112;	// 030007 ( 00112 )
	_030008 : int := 00113;	// 030008 ( 00113 )
	_030009 : int := 00114;	// 030009 ( 00114 )
	_030010 : int := 00115;	// 030010 ( 00115 )
	_040001 : int := 02614;	// 040001 ( 02614 )
	_040002 : int := 02615;	// 040002 ( 02615 )
	_040003 : int := 02616;	// 040003 ( 02616 )
	_040004 : int := 02617;	// 040004 ( 02617 )
	_050001 : int := 00116;	// 050001 ( 00116 )
	_050002 : int := 02618;	// 050002 ( 02618 )
	_050003 : int := 02619;	// 050003 ( 02619 )
	_050004 : int := 02620;	// 050004 ( 02620 )
	_050005 : int := 02621;	// 050005 ( 02621 )
	_050006 : int := 02622;	// 050006 ( 02622 )
	_050007 : int := 02623;	// 050007 ( 02623 )
	_050008 : int := 02624;	// 050008 ( 02624 )
	_050009 : int := 02625;	// 050009 ( 02625 )
	_050010 : int := 00117;	// 050010 ( 00117 )
	_050011 : int := 00118;	// 050011 ( 00118 )
	_050101 : int := 02626;	// 050101 ( 02626 )
	_050102 : int := 02627;	// 050102 ( 02627 )
	_050103 : int := 02628;	// 050103 ( 02628 )
	_050104 : int := 02629;	// 050104 ( 02629 )
	_050105 : int := 02630;	// 050105 ( 02630 )
	_050106 : int := 02631;	// 050106 ( 02631 )
	_050107 : int := 02632;	// 050107 ( 02632 )
	_050108 : int := 02633;	// 050108 ( 02633 )
	_050109 : int := 02634;	// 050109 ( 02634 )
	_050110 : int := 00119;	// 050110 ( 00119 )
	_050111 : int := 00120;	// 050111 ( 00120 )
	_050112 : int := 00121;	// 050112 ( 00121 )
	_050113 : int := 00122;	// 050113 ( 00122 )
	_050114 : int := 00123;	// 050114 ( 00123 )
	_050115 : int := 02635;	// 050115 ( 02635 )
	_050116 : int := 00124;	// 050116 ( 00124 )
	_050117 : int := 05004;	// 050117 ( 05004 )
	_050119 : int := 05005;	// 050119 ( 05005 )
	_050120 : int := 05006;	// 050120 ( 05006 )
	_050121 : int := 05007;	// 050121 ( 05007 )
	_050122 : int := 05008;	// 050122 ( 05008 )
	_050123 : int := 00125;	// 050123 ( 00125 )
	_050126 : int := 00126;	// 050126 ( 00126 )
	_050127 : int := 05009;	// 050127 ( 05009 )
	_050128 : int := 05010;	// 050128 ( 05010 )
	_050129 : int := 00127;	// 050129 ( 00127 )
	_050201 : int := 02636;	// 050201 ( 02636 )
	_050202 : int := 02637;	// 050202 ( 02637 )
	_050203 : int := 02638;	// 050203 ( 02638 )
	_050204 : int := 02639;	// 050204 ( 02639 )
	_050205 : int := 02640;	// 050205 ( 02640 )
	_050206 : int := 02641;	// 050206 ( 02641 )
	_050207 : int := 02642;	// 050207 ( 02642 )
	_050208 : int := 02643;	// 050208 ( 02643 )
	_050209 : int := 02644;	// 050209 ( 02644 )
	_050210 : int := 00128;	// 050210 ( 00128 )
	_050211 : int := 00129;	// 050211 ( 00129 )
	_050212 : int := 00130;	// 050212 ( 00130 )
	_050213 : int := 00131;	// 050213 ( 00131 )
	_050214 : int := 00132;	// 050214 ( 00132 )
	_050215 : int := 02645;	// 050215 ( 02645 )
	_050216 : int := 00133;	// 050216 ( 00133 )
	_050217 : int := 05011;	// 050217 ( 05011 )
	_050219 : int := 05012;	// 050219 ( 05012 )
	_050220 : int := 05013;	// 050220 ( 05013 )
	_050221 : int := 05014;	// 050221 ( 05014 )
	_050222 : int := 05015;	// 050222 ( 05015 )
	_050223 : int := 00134;	// 050223 ( 00134 )
	_050226 : int := 00135;	// 050226 ( 00135 )
	_050227 : int := 05016;	// 050227 ( 05016 )
	_050228 : int := 05017;	// 050228 ( 05017 )
	_050229 : int := 00136;	// 050229 ( 00136 )
	_050301 : int := 02646;	// 050301 ( 02646 )
	_050302 : int := 02647;	// 050302 ( 02647 )
	_050303 : int := 02648;	// 050303 ( 02648 )
	_050304 : int := 02649;	// 050304 ( 02649 )
	_050305 : int := 02650;	// 050305 ( 02650 )
	_050306 : int := 02651;	// 050306 ( 02651 )
	_050307 : int := 02652;	// 050307 ( 02652 )
	_050308 : int := 02653;	// 050308 ( 02653 )
	_050309 : int := 02654;	// 050309 ( 02654 )
	_050310 : int := 00137;	// 050310 ( 00137 )
	_050311 : int := 00138;	// 050311 ( 00138 )
	_050312 : int := 00139;	// 050312 ( 00139 )
	_050313 : int := 00140;	// 050313 ( 00140 )
	_050314 : int := 00141;	// 050314 ( 00141 )
	_050315 : int := 02655;	// 050315 ( 02655 )
	_050316 : int := 00142;	// 050316 ( 00142 )
	_050317 : int := 05018;	// 050317 ( 05018 )
	_050319 : int := 05019;	// 050319 ( 05019 )
	_050320 : int := 05020;	// 050320 ( 05020 )
	_050321 : int := 05021;	// 050321 ( 05021 )
	_050322 : int := 05022;	// 050322 ( 05022 )
	_050323 : int := 00143;	// 050323 ( 00143 )
	_050326 : int := 00144;	// 050326 ( 00144 )
	_050327 : int := 05023;	// 050327 ( 05023 )
	_050328 : int := 05024;	// 050328 ( 05024 )
	_050329 : int := 00145;	// 050329 ( 00145 )
	_050401 : int := 02656;	// 050401 ( 02656 )
	_050402 : int := 02657;	// 050402 ( 02657 )
	_050403 : int := 02658;	// 050403 ( 02658 )
	_050404 : int := 02659;	// 050404 ( 02659 )
	_050405 : int := 02660;	// 050405 ( 02660 )
	_050406 : int := 02661;	// 050406 ( 02661 )
	_050407 : int := 02662;	// 050407 ( 02662 )
	_050408 : int := 02663;	// 050408 ( 02663 )
	_050409 : int := 02664;	// 050409 ( 02664 )
	_050410 : int := 00146;	// 050410 ( 00146 )
	_050411 : int := 00147;	// 050411 ( 00147 )
	_050412 : int := 00148;	// 050412 ( 00148 )
	_050413 : int := 00149;	// 050413 ( 00149 )
	_050414 : int := 00150;	// 050414 ( 00150 )
	_050415 : int := 02665;	// 050415 ( 02665 )
	_050416 : int := 00151;	// 050416 ( 00151 )
	_050417 : int := 05025;	// 050417 ( 05025 )
	_050419 : int := 05026;	// 050419 ( 05026 )
	_050420 : int := 05027;	// 050420 ( 05027 )
	_050421 : int := 05028;	// 050421 ( 05028 )
	_050422 : int := 05029;	// 050422 ( 05029 )
	_050423 : int := 00152;	// 050423 ( 00152 )
	_050426 : int := 00153;	// 050426 ( 00153 )
	_050501 : int := 02666;	// 050501 ( 02666 )
	_050502 : int := 02667;	// 050502 ( 02667 )
	_050503 : int := 02668;	// 050503 ( 02668 )
	_050504 : int := 02669;	// 050504 ( 02669 )
	_050505 : int := 00154;	// 050505 ( 00154 )
	_050506 : int := 00155;	// 050506 ( 00155 )
	_050507 : int := 00156;	// 050507 ( 00156 )
	_050508 : int := 00157;	// 050508 ( 00157 )
	_050509 : int := 00158;	// 050509 ( 00158 )
	_050510 : int := 00159;	// 050510 ( 00159 )
	_050511 : int := 00160;	// 050511 ( 00160 )
	_050512 : int := 00161;	// 050512 ( 00161 )
	_050513 : int := 00162;	// 050513 ( 00162 )
	_050514 : int := 00163;	// 050514 ( 00163 )
	_060101 : int := 02670;	// 060101 ( 02670 )
	_060102 : int := 02671;	// 060102 ( 02671 )
	_060103 : int := 02672;	// 060103 ( 02672 )
	_060104 : int := 02673;	// 060104 ( 02673 )
	_060105 : int := 02674;	// 060105 ( 02674 )
	_060106 : int := 02675;	// 060106 ( 02675 )
	_060107 : int := 02676;	// 060107 ( 02676 )
	_060108 : int := 00164;	// 060108 ( 00164 )
	_060109 : int := 02677;	// 060109 ( 02677 )
	_060110 : int := 02678;	// 060110 ( 02678 )
	_060111 : int := 02679;	// 060111 ( 02679 )
	_060112 : int := 02680;	// 060112 ( 02680 )
	_060113 : int := 02681;	// 060113 ( 02681 )
	_060114 : int := 02682;	// 060114 ( 02682 )
	_060115 : int := 02683;	// 060115 ( 02683 )
	_060116 : int := 02684;	// 060116 ( 02684 )
	_060117 : int := 02685;	// 060117 ( 02685 )
	_060118 : int := 02686;	// 060118 ( 02686 )
	_060119 : int := 00165;	// 060119 ( 00165 )
	_060120 : int := 00166;	// 060120 ( 00166 )
	_060121 : int := 02687;	// 060121 ( 02687 )
	_060122 : int := 02688;	// 060122 ( 02688 )
	_060123 : int := 02689;	// 060123 ( 02689 )
	_060124 : int := 02690;	// 060124 ( 02690 )
	_060125 : int := 02691;	// 060125 ( 02691 )
	_060126 : int := 02692;	// 060126 ( 02692 )
	_060127 : int := 02693;	// 060127 ( 02693 )
	_060128 : int := 02694;	// 060128 ( 02694 )
	_060129 : int := 02695;	// 060129 ( 02695 )
	_060130 : int := 02696;	// 060130 ( 02696 )
	_060131 : int := 02697;	// 060131 ( 02697 )
	_060132 : int := 02698;	// 060132 ( 02698 )
	_060133 : int := 02699;	// 060133 ( 02699 )
	_060134 : int := 02700;	// 060134 ( 02700 )
	_060135 : int := 02701;	// 060135 ( 02701 )
	_060136 : int := 02702;	// 060136 ( 02702 )
	_060137 : int := 02703;	// 060137 ( 02703 )
	_060138 : int := 02704;	// 060138 ( 02704 )
	_060139 : int := 02705;	// 060139 ( 02705 )
	_060140 : int := 02706;	// 060140 ( 02706 )
	_060141 : int := 02707;	// 060141 ( 02707 )
	_060142 : int := 02708;	// 060142 ( 02708 )
	_060143 : int := 02709;	// 060143 ( 02709 )
	_060150A : int := 00167;	// 060150A ( 00167 )
	_060150C : int := 05030;	// 060150C ( 05030 )
	_060150S : int := 05031;	// 060150S ( 05031 )
	_060151A : int := 00168;	// 060151A ( 00168 )
	_060151C : int := 05032;	// 060151C ( 05032 )
	_060151S : int := 05033;	// 060151S ( 05033 )
	_060201 : int := 02710;	// 060201 ( 02710 )
	_060202 : int := 00169;	// 060202 ( 00169 )
	_060203 : int := 00170;	// 060203 ( 00170 )
	_060204 : int := 02711;	// 060204 ( 02711 )
	_060205 : int := 00171;	// 060205 ( 00171 )
	_060206 : int := 02712;	// 060206 ( 02712 )
	_060207 : int := 02713;	// 060207 ( 02713 )
	_060250A : int := 00172;	// 060250A ( 00172 )
	_060250C : int := 05034;	// 060250C ( 05034 )
	_060250S : int := 05035;	// 060250S ( 05035 )
	_060252A : int := 00173;	// 060252A ( 00173 )
	_060252C : int := 05036;	// 060252C ( 05036 )
	_060252S : int := 05037;	// 060252S ( 05037 )
	_060301 : int := 02714;	// 060301 ( 02714 )
	_060302 : int := 02715;	// 060302 ( 02715 )
	_060303 : int := 02716;	// 060303 ( 02716 )
	_060304 : int := 02717;	// 060304 ( 02717 )
	_060305 : int := 02718;	// 060305 ( 02718 )
	_060306 : int := 02719;	// 060306 ( 02719 )
	_060307 : int := 02720;	// 060307 ( 02720 )
	_060308 : int := 02721;	// 060308 ( 02721 )
	_060309 : int := 02722;	// 060309 ( 02722 )
	_060310 : int := 02723;	// 060310 ( 02723 )
	_060401 : int := 02724;	// 060401 ( 02724 )
	_060402 : int := 02725;	// 060402 ( 02725 )
	_060403 : int := 02726;	// 060403 ( 02726 )
	_060404 : int := 02727;	// 060404 ( 02727 )
	_060405 : int := 02728;	// 060405 ( 02728 )
	_060406 : int := 02729;	// 060406 ( 02729 )
	_060407 : int := 02730;	// 060407 ( 02730 )
	_060408 : int := 02731;	// 060408 ( 02731 )
	_060450A : int := 00174;	// 060450A ( 00174 )
	_060450C : int := 05038;	// 060450C ( 05038 )
	_060450S : int := 05039;	// 060450S ( 05039 )
	_060452A : int := 00175;	// 060452A ( 00175 )
	_060452C : int := 05040;	// 060452C ( 05040 )
	_060452S : int := 05041;	// 060452S ( 05041 )
	_060453A : int := 00176;	// 060453A ( 00176 )
	_060453C : int := 05042;	// 060453C ( 05042 )
	_060453S : int := 05043;	// 060453S ( 05043 )
	_060454A : int := 00177;	// 060454A ( 00177 )
	_060454C : int := 05044;	// 060454C ( 05044 )
	_060454S : int := 05045;	// 060454S ( 05045 )
	_060501 : int := 00178;	// 060501 ( 00178 )
	_060502 : int := 00179;	// 060502 ( 00179 )
	_060503 : int := 00180;	// 060503 ( 00180 )
	_060504 : int := 00181;	// 060504 ( 00181 )
	_060505 : int := 00182;	// 060505 ( 00182 )
	_060506 : int := 00183;	// 060506 ( 00183 )
	_060507 : int := 00184;	// 060507 ( 00184 )
	_060508 : int := 00185;	// 060508 ( 00185 )
	_060509 : int := 00186;	// 060509 ( 00186 )
	_060510 : int := 00187;	// 060510 ( 00187 )
	_070101 : int := 02732;	// 070101 ( 02732 )
	_070102 : int := 00188;	// 070102 ( 00188 )
	_070103 : int := 02733;	// 070103 ( 02733 )
	_070104 : int := 00189;	// 070104 ( 00189 )
	_070150A : int := 00190;	// 070150A ( 00190 )
	_070150C : int := 05046;	// 070150C ( 05046 )
	_070150S : int := 05047;	// 070150S ( 05047 )
	_070151A : int := 00191;	// 070151A ( 00191 )
	_070151C : int := 05048;	// 070151C ( 05048 )
	_070151S : int := 05049;	// 070151S ( 05049 )
	_080101 : int := 00192;	// 080101 ( 00192 )
	_080102 : int := 00193;	// 080102 ( 00193 )
	_080103 : int := 00194;	// 080103 ( 00194 )
	_080104 : int := 00195;	// 080104 ( 00195 )
	_080105 : int := 00196;	// 080105 ( 00196 )
	_080106 : int := 00197;	// 080106 ( 00197 )
	AAGRH_A : int := 05372;	// AAGRH_A ( 05372 )
	AAGRS_A : int := 05373;	// AAGRS_A ( 05373 )
	AAGR_1_A : int := 05374;	// AAGR_1_A ( 05374 )
	AAGR_2_A : int := 05375;	// AAGR_2_A ( 05375 )
	AAGR_3_A : int := 05376;	// AAGR_3_A ( 05376 )
	AAGR_4_A : int := 05377;	// AAGR_4_A ( 05377 )
	AAGR_5_A : int := 05378;	// AAGR_5_A ( 05378 )
	AAGR_6_A : int := 05379;	// AAGR_6_A ( 05379 )
	AAGR_7_A : int := 05380;	// AAGR_7_A ( 05380 )
	WDGEAS01 : int := 05398;	// WDGEAS01 ( 05398 )
	WDGEAS02 : int := 05399;	// WDGEAS02 ( 05399 )
	WDGEAS03 : int := 05400;	// WDGEAS03 ( 05400 )
	WDGEAS04 : int := 05401;	// WDGEAS04 ( 05401 )
	WDGEAS05 : int := 05402;	// WDGEAS05 ( 05402 )
	WDGEAS06 : int := 05403;	// WDGEAS06 ( 05403 )
	WDGEAS07 : int := 05404;	// WDGEAS07 ( 05404 )
	WDGEAS08 : int := 05405;	// WDGEAS08 ( 05405 )
	WDGOS99 : int := 05406;	// WDGOS99 ( 05406 )
	WDGPRC01 : int := 05407;	// WDGPRC01 ( 05407 )
	WDGPRC02 : int := 05408;	// WDGPRC02 ( 05408 )
	WDGPRC03 : int := 05409;	// WDGPRC03 ( 05409 )
	WDGPRC04 : int := 05410;	// WDGPRC04 ( 05410 )
	WDGPRC05 : int := 05411;	// WDGPRC05 ( 05411 )
	WDGPRC06 : int := 05412;	// WDGPRC06 ( 05412 )
	WDGPRC07 : int := 05413;	// WDGPRC07 ( 05413 )
	WDGPRC08 : int := 05414;	// WDGPRC08 ( 05414 )
	WDGUDP01 : int := 05415;	// WDGUDP01 ( 05415 )
	WDGUDP02 : int := 05416;	// WDGUDP02 ( 05416 )
	WDGUDP03 : int := 05417;	// WDGUDP03 ( 05417 )
	WDGUDP04 : int := 05418;	// WDGUDP04 ( 05418 )
	WDGUDP05 : int := 05419;	// WDGUDP05 ( 05419 )
	WDGUDP06 : int := 05420;	// WDGUDP06 ( 05420 )
	WDGUDP07 : int := 05421;	// WDGUDP07 ( 05421 )
	WDGUDP08 : int := 05422;	// WDGUDP08 ( 05422 )
	_BG01 : int := 00198;	// _BG01 ( 00198 )
	_BG02 : int := 00199;	// _BG02 ( 00199 )
	_BG03 : int := 00200;	// _BG03 ( 00200 )
	_BG04 : int := 00201;	// _BG04 ( 00201 )
	_BG05 : int := 00202;	// _BG05 ( 00202 )
	_BG06 : int := 00203;	// _BG06 ( 00203 )
	_BG07 : int := 00204;	// _BG07 ( 00204 )
	_BG08 : int := 00205;	// _BG08 ( 00205 )
	_BG09 : int := 00206;	// _BG09 ( 00206 )
	_BG10 : int := 00207;	// _BG10 ( 00207 )
	END_STRUCT
	BEGIN
	END_DATA_BLOCK

	DATA_BLOCK DB 184
	TITLE =
	AUTHOR : AV_ET
	FAMILY : AbvSpu
	Name : DB_184
	VERSION : 0.0
	STRUCT
	D_0 : word := B#(  2,  3);	//  010134 ( 02500 )
	D_1 : word := 2#0000000000000100;	// ME CAJA ENGRANES PRES LUB
	D_2 : real := +0.0;
	D_3 : word := 2#0000000000000000;
	D_4 : int  := +00000;
	D_5 : int  := +00000;
	D_6 : int  := +00000;
	D_7 : word := B#(  0, 0);
	D_8 : word := B#(000,000);
	D_9 : word := 2#0000000000000000;
	D_10 : int  := +00000;
	D_11 : int  := +00000;
	D_12 : word := B#(  1,  1);	// State (1)
	D_13 : word := B#(  0,  0);	//
	D_14 : word := B#(  0,  0);	//
	D_15 : int  := +00000;	//
	D_16 : word := 2#0000000000000000;	//
	D_17 : word := B#(  0,  0);	//
	D_18 : word := B#(  1,  1);	// State (2)
	D_19 : word := B#(  0,  1);	//
	D_20 : word := B#(  3,  5);	//
	D_21 : int  := +00000;	//
	D_22 : word := 2#0000000000000000;	//
	D_23 : word := B#(  0,  0);	//
	D_24 : word := B#(  1,  1);	// State (3)
	D_25 : word := B#(  0,  1);	//
	D_26 : word := B#(  15,  1);	//
	D_27 : int  := +00000;	//
	D_28 : word := 2#0000000000000000;	//
	D_29 : word := B#(  0,  0);	//
	D_30 : word := B#(  1,  1);	// State (16)
	D_31 : word := B#(  0,  1);	//
	D_32 : word := B#(  15,  12);	//
	D_33 : int  := +00000;	//
	D_34 : word := 2#0000000000000000;	//
	D_35 : word := B#(  0,  0);	//
	D_36 : real := 0.000000000000;	//
	D_37 : real := 350.000000000000;	//
	D_38 : real := 0.000000000000;	//
	D_39 : real := 1.750000000000;	//
	D_40 : real := +0.0;	//
	D_41 : int  := 00000;	//
	D_42 : int  := 00000;	//
	D_43 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_44 : int  := 00000;	//
	D_45 : int  := +00000;	//
	D_46 : word  := B#(000,000);	//
	D_47 : int  := +00000;	//
	D_48 : real := 232.000000000000;	// Limit (1)
	D_49 : real := +0.0;	//
	D_50 : int  := +00000;	//
	D_51 : word := 2#0000000000000000;	//
	D_52 : int := +00000;	//
	D_53 : real := 230.000000000000;	// Limit (2)
	D_54 : real := +0.0;	//
	D_55 : int  := +00000;	//
	D_56 : word := 2#0000000000000000;	//
	D_57 : int := +00000;	//
	D_58 : word := B#(  2,  5);	//  010135 ( 02501 )
	D_59 : word := 2#0000000000000100;	// ME PRES ACEITE DESPUES DEL F.
	D_60 : real := +0.0;
	D_61 : word := 2#0000000000000000;
	D_62 : int  := +00000;
	D_63 : int  := +00000;
	D_64 : int  := +00000;
	D_65 : word := B#(  0, 0);
	D_66 : word := B#(000,000);
	D_67 : word := 2#0000000000000000;
	D_68 : int  := +00000;
	D_69 : int  := +00000;
	D_70 : word := B#(  1,  1);	// State (1)
	D_71 : word := B#(  0,  0);	//
	D_72 : word := B#(  0,  0);	//
	D_73 : int  := +00000;	//
	D_74 : word := 2#0000000000000000;	//
	D_75 : word := B#(  0,  0);	//
	D_76 : word := B#(  1,  1);	// State (2)
	D_77 : word := B#(  0,  1);	//
	D_78 : word := B#(  3,  5);	//
	D_79 : int  := +00000;	//
	D_80 : word := 2#0000000000000000;	//
	D_81 : word := B#(  0,  0);	//
	D_82 : word := B#(  1,  1);	// State (3)
	D_83 : word := B#(  0,  1);	//
	D_84 : word := B#(  5,  9);	//
	D_85 : int  := +00000;	//
	D_86 : word := 2#0000000000000000;	//
	D_87 : word := B#(  0,  0);	//
	D_88 : word := B#(  1,  1);	// State (4)
	D_89 : word := B#(  0,  1);	//
	D_90 : word := B#(  3,  5);	//
	D_91 : int  := +00000;	//
	D_92 : word := 2#0000000000000000;	//
	D_93 : word := B#(  0,  0);	//
	D_94 : word := B#(  1,  1);	// State (5)
	D_95 : word := B#(  0,  1);	//
	D_96 : word := B#(  5,  9);	//
	D_97 : int  := +00000;	//
	D_98 : word := 2#0000000000000000;	//
	D_99 : word := B#(  0,  0);	//
	D_100 : word := B#(  1,  1);	// State (16)
	D_101 : word := B#(  0,  1);	//
	D_102 : word := B#(  15,  12);	//
	D_103 : int  := +00000;	//
	D_104 : word := 2#0000000000000000;	//
	D_105 : word := B#(  0,  0);	//
	D_106 : real := 0.000000000000;	//
	D_107 : real := 145.000000000000;	//
	D_108 : real := 1.450000000000;	//
	D_109 : real := 1.450000000000;	//
	D_110 : real := +0.0;	//
	D_111 : int  := 00000;	//
	D_112 : int  := 00000;	//
	D_113 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_114 : int  := 00000;	//
	D_115 : int  := +00000;	//
	D_116 : word  := B#(000,000);	//
	D_117 : int  := +00000;	//
	D_118 : real := 46.000000000000;	// Limit (1)
	D_119 : real := +0.0;	//
	D_120 : int  := +00000;	//
	D_121 : word := 2#0000000000000000;	//
	D_122 : int := +00000;	//
	D_123 : real := 38.000000000000;	// Limit (2)
	D_124 : real := +0.0;	//
	D_125 : int  := +00000;	//
	D_126 : word := 2#0000000000000000;	//
	D_127 : int := +00000;	//
	D_128 : real := 17.000000000000;	// Limit (3)
	D_129 : real := +0.0;	//
	D_130 : int  := +00000;	//
	D_131 : word := 2#0000000000000000;	//
	D_132 : int := +00000;	//
	D_133 : real := 15.000000000000;	// Limit (4)
	D_134 : real := +0.0;	//
	D_135 : int  := +00000;	//
	D_136 : word := 2#0000000000000000;	//
	D_137 : int := +00000;	//
	D_138 : word := B#(  2,  1);	//  010136 ( 02502 )
	D_139 : word := 2#0000000000000100;	// ME PRES ACEITE ANTES DEL F.
	D_140 : real := +0.0;
	D_141 : word := 2#0000000000000000;
	D_142 : int  := +00000;
	D_143 : int  := +00000;
	D_144 : int  := +00000;
	D_145 : word := B#(  0, 0);
	D_146 : word := B#(000,000);
	D_147 : word := 2#0000000000000000;
	D_148 : int  := +00000;
	D_149 : int  := +00000;
	D_150 : word := B#(  1,  1);	// State (1)
	D_151 : word := B#(  0,  0);	//
	D_152 : word := B#(  0,  0);	//
	D_153 : int  := +00000;	//
	D_154 : word := 2#0000000000000000;	//
	D_155 : word := B#(  0,  0);	//
	D_156 : word := B#(  1,  1);	// State (16)
	D_157 : word := B#(  0,  1);	//
	D_158 : word := B#(  15,  12);	//
	D_159 : int  := +00000;	//
	D_160 : word := 2#0000000000000000;	//
	D_161 : word := B#(  0,  0);	//
	D_162 : real := 0.000000000000;	//
	D_163 : real := 145.000000000000;	//
	D_164 : real := 0.000000000000;	//
	D_165 : real := 0.725000000000;	//
	D_166 : real := +0.0;	//
	D_167 : int  := 00000;	//
	D_168 : int  := 00000;	//
	D_169 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_170 : int  := 00000;	//
	D_171 : int  := +00000;	//
	D_172 : word  := B#(000,000);	//
	D_173 : int  := +00000;	//
	D_174 : word := B#(  2,  3);	//  010137 ( 02503 )
	D_175 : word := 2#0000000000000100;	// ME PRES COMB DESPUES FILTRO
	D_176 : real := +0.0;
	D_177 : word := 2#0000000000000000;
	D_178 : int  := +00000;
	D_179 : int  := +00000;
	D_180 : int  := +00000;
	D_181 : word := B#(  0, 0);
	D_182 : word := B#(000,000);
	D_183 : word := 2#0000000000000000;
	D_184 : int  := +00000;
	D_185 : int  := +00000;
	D_186 : word := B#(  1,  1);	// State (1)
	D_187 : word := B#(  0,  0);	//
	D_188 : word := B#(  0,  0);	//
	D_189 : int  := +00000;	//
	D_190 : word := 2#0000000000000000;	//
	D_191 : word := B#(  0,  0);	//
	D_192 : word := B#(  1,  1);	// State (2)
	D_193 : word := B#(  0,  1);	//
	D_194 : word := B#(  3,  5);	//
	D_195 : int  := +00000;	//
	D_196 : word := 2#0000000000000000;	//
	D_197 : word := B#(  0,  0);	//
	D_198 : word := B#(  1,  1);	// State (3)
	D_199 : word := B#(  0,  1);	//
	D_200 : word := B#(  5,  9);	//
	D_201 : int  := +00000;	//
	D_202 : word := 2#0000000000000000;	//
	D_203 : word := B#(  0,  0);	//
	D_204 : word := B#(  1,  1);	// State (16)
	D_205 : word := B#(  0,  1);	//
	D_206 : word := B#(  15,  12);	//
	D_207 : int  := +00000;	//
	D_208 : word := 2#0000000000000000;	//
	D_209 : word := B#(  0,  0);	//
	D_210 : real := 0.000000000000;	//
	D_211 : real := 145.000000000000;	//
	D_212 : real := 0.000000000000;	//
	D_213 : real := 0.725000000000;	//
	D_214 : real := +0.0;	//
	D_215 : int  := 00000;	//
	D_216 : int  := 00000;	//
	D_217 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_218 : int  := 00000;	//
	D_219 : int  := +00000;	//
	D_220 : word  := B#(000,000);	//
	D_221 : int  := +00000;	//
	D_222 : real := 35.000000000000;	// Limit (1)
	D_223 : real := +0.0;	//
	D_224 : int  := +00000;	//
	D_225 : word := 2#0000000000000000;	//
	D_226 : int := +00000;	//
	D_227 : real := 15.250000000000;	// Limit (2)
	D_228 : real := +0.0;	//
	D_229 : int  := +00000;	//
	D_230 : word := 2#0000000000000000;	//
	D_231 : int := +00000;	//
	D_232 : word := B#(  2,  1);	//  010138 ( 02504 )
	D_233 : word := 2#0000000000000100;	// ME PRES COMB ANTES  DEL FILTRO
	D_234 : real := +0.0;
	D_235 : word := 2#0000000000000000;
	D_236 : int  := +00000;
	D_237 : int  := +00000;
	D_238 : int  := +00000;
	D_239 : word := B#(  0, 0);
	D_240 : word := B#(000,000);
	D_241 : word := 2#0000000000000000;
	D_242 : int  := +00000;
	D_243 : int  := +00000;
	D_244 : word := B#(  1,  1);	// State (1)
	D_245 : word := B#(  0,  0);	//
	D_246 : word := B#(  0,  0);	//
	D_247 : int  := +00000;	//
	D_248 : word := 2#0000000000000000;	//
	D_249 : word := B#(  0,  0);	//
	D_250 : word := B#(  1,  1);	// State (16)
	D_251 : word := B#(  0,  1);	//
	D_252 : word := B#(  15,  12);	//
	D_253 : int  := +00000;	//
	D_254 : word := 2#0000000000000000;	//
	D_255 : word := B#(  0,  0);	//
	D_256 : real := 0.000000000000;	//
	D_257 : real := 145.000000000000;	//
	D_258 : real := 0.000000000000;	//
	D_259 : real := 0.725000000000;	//
	D_260 : real := +0.0;	//
	D_261 : int  := 00000;	//
	D_262 : int  := 00000;	//
	D_263 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_264 : int  := 00000;	//
	D_265 : int  := +00000;	//
	D_266 : word  := B#(000,000);	//
	D_267 : int  := +00000;	//
	D_268 : word := B#(  2,  2);	//  010139 ( 02505 )
	D_269 : word := 2#0000000000000100;	// ME PRES AGUA DE MAR
	D_270 : real := +0.0;
	D_271 : word := 2#0000000000000000;
	D_272 : int  := +00000;
	D_273 : int  := +00000;
	D_274 : int  := +00000;
	D_275 : word := B#(  0, 0);
	D_276 : word := B#(000,000);
	D_277 : word := 2#0000000000000000;
	D_278 : int  := +00000;
	D_279 : int  := +00000;
	D_280 : word := B#(  1,  1);	// State (1)
	D_281 : word := B#(  0,  0);	//
	D_282 : word := B#(  0,  0);	//
	D_283 : int  := +00000;	//
	D_284 : word := 2#0000000000000000;	//
	D_285 : word := B#(  0,  0);	//
	D_286 : word := B#(  1,  1);	// State (2)
	D_287 : word := B#(  0,  1);	//
	D_288 : word := B#(  3,  5);	//
	D_289 : int  := +00000;	//
	D_290 : word := 2#0000000000000000;	//
	D_291 : word := B#(  0,  0);	//
	D_292 : word := B#(  1,  1);	// State (16)
	D_293 : word := B#(  0,  1);	//
	D_294 : word := B#(  15,  12);	//
	D_295 : int  := +00000;	//
	D_296 : word := 2#0000000000000000;	//
	D_297 : word := B#(  0,  0);	//
	D_298 : real := 0.000000000000;	//
	D_299 : real := 145.000000000000;	//
	D_300 : real := 0.000000000000;	//
	D_301 : real := 0.725000000000;	//
	D_302 : real := +0.0;	//
	D_303 : int  := 00000;	//
	D_304 : int  := 00000;	//
	D_305 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_306 : int  := 00000;	//
	D_307 : int  := +00000;	//
	D_308 : word  := B#(000,000);	//
	D_309 : int  := +00000;	//
	D_310 : real := 5.000000000000;	// Limit (1)
	D_311 : real := +0.0;	//
	D_312 : int  := +00000;	//
	D_313 : word := 2#0000000000000000;	//
	D_314 : int := +00000;	//
	D_315 : word := B#(  2,  2);	//  010140 ( 02506 )
	D_316 : word := 2#0000000000000100;	// ME PRES AIRE DE ARRANQUE
	D_317 : real := +0.0;
	D_318 : word := 2#0000000000000000;
	D_319 : int  := +00000;
	D_320 : int  := +00000;
	D_321 : int  := +00000;
	D_322 : word := B#(  0, 0);
	D_323 : word := B#(000,000);
	D_324 : word := 2#0000000000000000;
	D_325 : int  := +00000;
	D_326 : int  := +00000;
	D_327 : word := B#(  1,  1);	// State (1)
	D_328 : word := B#(  0,  0);	//
	D_329 : word := B#(  0,  0);	//
	D_330 : int  := +00000;	//
	D_331 : word := 2#0000000000000000;	//
	D_332 : word := B#(  0,  0);	//
	D_333 : word := B#(  1,  1);	// State (2)
	D_334 : word := B#(  0,  1);	//
	D_335 : word := B#(  5,  9);	//
	D_336 : int  := +00000;	//
	D_337 : word := 2#0000000000000000;	//
	D_338 : word := B#(  0,  0);	//
	D_339 : word := B#(  1,  1);	// State (16)
	D_340 : word := B#(  0,  1);	//
	D_341 : word := B#(  15,  12);	//
	D_342 : int  := +00000;	//
	D_343 : word := 2#0000000000000000;	//
	D_344 : word := B#(  0,  0);	//
	D_345 : real := 0.000000000000;	//
	D_346 : real := 400.000000000000;	//
	D_347 : real := 0.000000000000;	//
	D_348 : real := 2.000000000000;	//
	D_349 : real := +0.0;	//
	D_350 : int  := 00000;	//
	D_351 : int  := 00000;	//
	D_352 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_353 : int  := 00000;	//
	D_354 : int  := +00000;	//
	D_355 : word  := B#(000,000);	//
	D_356 : int  := +00000;	//
	D_357 : real := 110.000000000000;	// Limit (1)
	D_358 : real := +0.0;	//
	D_359 : int  := +00000;	//
	D_360 : word := 2#0000000000000000;	//
	D_361 : int := +00000;	//
	D_362 : word := B#(  2,  3);	//  010141 ( 02507 )
	D_363 : word := 2#0000000000000100;	// ME PRES  AGUA DE CAMISAS
	D_364 : real := +0.0;
	D_365 : word := 2#0000000000000000;
	D_366 : int  := +00000;
	D_367 : int  := +00000;
	D_368 : int  := +00000;
	D_369 : word := B#(  0, 0);
	D_370 : word := B#(000,000);
	D_371 : word := 2#0000000000000000;
	D_372 : int  := +00000;
	D_373 : int  := +00000;
	D_374 : word := B#(  1,  1);	// State (1)
	D_375 : word := B#(  0,  0);	//
	D_376 : word := B#(  0,  0);	//
	D_377 : int  := +00000;	//
	D_378 : word := 2#0000000000000000;	//
	D_379 : word := B#(  0,  0);	//
	D_380 : word := B#(  1,  1);	// State (2)
	D_381 : word := B#(  0,  1);	//
	D_382 : word := B#(  3,  5);	//
	D_383 : int  := +00000;	//
	D_384 : word := 2#0000000000000000;	//
	D_385 : word := B#(  0,  0);	//
	D_386 : word := B#(  1,  1);	// State (3)
	D_387 : word := B#(  0,  1);	//
	D_388 : word := B#(  5,  9);	//
	D_389 : int  := +00000;	//
	D_390 : word := 2#0000000000000000;	//
	D_391 : word := B#(  0,  0);	//
	D_392 : word := B#(  1,  1);	// State (16)
	D_393 : word := B#(  0,  1);	//
	D_394 : word := B#(  15,  12);	//
	D_395 : int  := +00000;	//
	D_396 : word := 2#0000000000000000;	//
	D_397 : word := B#(  0,  0);	//
	D_398 : real := 0.000000000000;	//
	D_399 : real := 145.000000000000;	//
	D_400 : real := 0.000000000000;	//
	D_401 : real := 0.725000000000;	//
	D_402 : real := +0.0;	//
	D_403 : int  := 00000;	//
	D_404 : int  := 00000;	//
	D_405 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_406 : int  := 00000;	//
	D_407 : int  := +00000;	//
	D_408 : word  := B#(000,000);	//
	D_409 : int  := +00000;	//
	D_410 : real := 5.000000000000;	// Limit (1)
	D_411 : real := +0.0;	//
	D_412 : int  := +00000;	//
	D_413 : word := 2#0000000000000000;	//
	D_414 : int := +00000;	//
	D_415 : real := 3.000000000000;	// Limit (2)
	D_416 : real := +0.0;	//
	D_417 : int  := +00000;	//
	D_418 : word := 2#0000000000000000;	//
	D_419 : int := +00000;	//
	D_420 : word := B#(  2,  2);	//  010142 ( 02508 )
	D_421 : word := 2#0000000000000100;	// ME PRES DE BOMBA AC/OC
	D_422 : real := +0.0;
	D_423 : word := 2#0000000000000000;
	D_424 : int  := +00000;
	D_425 : int  := +00000;
	D_426 : int  := +00000;
	D_427 : word := B#(  0, 0);
	D_428 : word := B#(000,000);
	D_429 : word := 2#0000000000000000;
	D_430 : int  := +00000;
	D_431 : int  := +00000;
	D_432 : word := B#(  1,  1);	// State (1)
	D_433 : word := B#(  0,  0);	//
	D_434 : word := B#(  0,  0);	//
	D_435 : int  := +00000;	//
	D_436 : word := 2#0000000000000000;	//
	D_437 : word := B#(  0,  0);	//
	D_438 : word := B#(  1,  1);	// State (2)
	D_439 : word := B#(  0,  1);	//
	D_440 : word := B#(  5,  9);	//
	D_441 : int  := +00000;	//
	D_442 : word := 2#0000000000000000;	//
	D_443 : word := B#(  0,  0);	//
	D_444 : word := B#(  1,  1);	// State (16)
	D_445 : word := B#(  0,  1);	//
	D_446 : word := B#(  15,  12);	//
	D_447 : int  := +00000;	//
	D_448 : word := 2#0000000000000000;	//
	D_449 : word := B#(  0,  0);	//
	D_450 : real := 0.000000000000;	//
	D_451 : real := 145.000000000000;	//
	D_452 : real := 0.000000000000;	//
	D_453 : real := 0.725000000000;	//
	D_454 : real := +0.0;	//
	D_455 : int  := 00000;	//
	D_456 : int  := 00000;	//
	D_457 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_458 : int  := 00000;	//
	D_459 : int  := +00000;	//
	D_460 : word  := B#(000,000);	//
	D_461 : int  := +00000;	//
	D_462 : real := 5.000000000000;	// Limit (1)
	D_463 : real := +0.0;	//
	D_464 : int  := +00000;	//
	D_465 : word := 2#0000000000000000;	//
	D_466 : int := +00000;	//
	D_467 : word := B#(  2,  2);	//  010143 ( 02509 )
	D_468 : word := 2#0000000000000100;	// ME PRES AIRE ENTRADA AL MULT
	D_469 : real := +0.0;
	D_470 : word := 2#0000000000000000;
	D_471 : int  := +00000;
	D_472 : int  := +00000;
	D_473 : int  := +00000;
	D_474 : word := B#(  0, 0);
	D_475 : word := B#(000,000);
	D_476 : word := 2#0000000000000000;
	D_477 : int  := +00000;
	D_478 : int  := +00000;
	D_479 : word := B#(  1,  1);	// State (1)
	D_480 : word := B#(  0,  1);	//
	D_481 : word := B#(  5,  8);	//
	D_482 : int  := +00000;	//
	D_483 : word := 2#0000000000000000;	//
	D_484 : word := B#(  0,  0);	//
	D_485 : word := B#(  1,  1);	// State (2)
	D_486 : word := B#(  0,  0);	//
	D_487 : word := B#(  0,  0);	//
	D_488 : int  := +00000;	//
	D_489 : word := 2#0000000000000000;	//
	D_490 : word := B#(  0,  0);	//
	D_491 : word := B#(  1,  1);	// State (16)
	D_492 : word := B#(  0,  1);	//
	D_493 : word := B#(  15,  12);	//
	D_494 : int  := +00000;	//
	D_495 : word := 2#0000000000000000;	//
	D_496 : word := B#(  0,  0);	//
	D_497 : real := 0.000000000000;	//
	D_498 : real := 145.000000000000;	//
	D_499 : real := 0.000000000000;	//
	D_500 : real := 0.725000000000;	//
	D_501 : real := +0.0;	//
	D_502 : int  := 00000;	//
	D_503 : int  := 00000;	//
	D_504 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_505 : int  := 00000;	//
	D_506 : int  := +00000;	//
	D_507 : word  := B#(000,000);	//
	D_508 : int  := +00000;	//
	D_509 : real := 45.000000000000;	// Limit (1)
	D_510 : real := +0.0;	//
	D_511 : int  := +00000;	//
	D_512 : word := 2#0000000000000000;	//
	D_513 : int := +00000;	//
	D_514 : word := B#(  2,  2);	//  010144 ( 02510 )
	D_515 : word := 2#0000000000000100;	// ME TEMP ACEITE DE LUBRICACION
	D_516 : real := +0.0;
	D_517 : word := 2#0000000000000000;
	D_518 : int  := +00000;
	D_519 : int  := +00000;
	D_520 : int  := +00000;
	D_521 : word := B#(  0, 0);
	D_522 : word := B#(000,000);
	D_523 : word := 2#0000000000000000;
	D_524 : int  := +00000;
	D_525 : int  := +00000;
	D_526 : word := B#(  1,  1);	// State (1)
	D_527 : word := B#(  0,  1);	//
	D_528 : word := B#(  5,  8);	//
	D_529 : int  := +00000;	//
	D_530 : word := 2#0000000000000000;	//
	D_531 : word := B#(  0,  0);	//
	D_532 : word := B#(  1,  1);	// State (2)
	D_533 : word := B#(  0,  0);	//
	D_534 : word := B#(  0,  0);	//
	D_535 : int  := +00000;	//
	D_536 : word := 2#0000000000000000;	//
	D_537 : word := B#(  0,  0);	//
	D_538 : word := B#(  1,  1);	// State (16)
	D_539 : word := B#(  0,  1);	//
	D_540 : word := B#(  15,  12);	//
	D_541 : int  := +00000;	//
	D_542 : word := 2#0000000000000000;	//
	D_543 : word := B#(  0,  0);	//
	D_544 : real := 0.000000000000;	//
	D_545 : real := 300.000000000000;	//
	D_546 : real := 0.000000000000;	//
	D_547 : real := 1.500000000000;	//
	D_548 : real := +0.0;	//
	D_549 : int  := 00000;	//
	D_550 : int  := 00000;	//
	D_551 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_552 : int  := 00000;	//
	D_553 : int  := +00000;	//
	D_554 : word  := B#(000,000);	//
	D_555 : int  := +00000;	//
	D_556 : real := 194.000000000000;	// Limit (1)
	D_557 : real := +0.0;	//
	D_558 : int  := +00000;	//
	D_559 : word := 2#0000000000000000;	//
	D_560 : int := +00000;	//
	D_561 : word := B#(  2,  2);	//  010145 ( 02511 )
	D_562 : word := 2#0000000000000100;	// ME TEMP DE AIRE ENT AL MULT
	D_563 : real := +0.0;
	D_564 : word := 2#0000000000000000;
	D_565 : int  := +00000;
	D_566 : int  := +00000;
	D_567 : int  := +00000;
	D_568 : word := B#(  0, 0);
	D_569 : word := B#(000,000);
	D_570 : word := 2#0000000000000000;
	D_571 : int  := +00000;
	D_572 : int  := +00000;
	D_573 : word := B#(  1,  1);	// State (1)
	D_574 : word := B#(  0,  1);	//
	D_575 : word := B#(  5,  8);	//
	D_576 : int  := +00000;	//
	D_577 : word := 2#0000000000000000;	//
	D_578 : word := B#(  0,  0);	//
	D_579 : word := B#(  1,  1);	// State (2)
	D_580 : word := B#(  0,  0);	//
	D_581 : word := B#(  0,  0);	//
	D_582 : int  := +00000;	//
	D_583 : word := 2#0000000000000000;	//
	D_584 : word := B#(  0,  0);	//
	D_585 : word := B#(  1,  1);	// State (16)
	D_586 : word := B#(  0,  1);	//
	D_587 : word := B#(  15,  12);	//
	D_588 : int  := +00000;	//
	D_589 : word := 2#0000000000000000;	//
	D_590 : word := B#(  0,  0);	//
	D_591 : real := 0.000000000000;	//
	D_592 : real := 300.000000000000;	//
	D_593 : real := 0.000000000000;	//
	D_594 : real := 1.500000000000;	//
	D_595 : real := +0.0;	//
	D_596 : int  := 00000;	//
	D_597 : int  := 00000;	//
	D_598 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_599 : int  := 00000;	//
	D_600 : int  := +00000;	//
	D_601 : word  := B#(000,000);	//
	D_602 : int  := +00000;	//
	D_603 : real := 198.000000000000;	// Limit (1)
	D_604 : real := +0.0;	//
	D_605 : int  := +00000;	//
	D_606 : word := 2#0000000000000000;	//
	D_607 : int := +00000;	//
	D_608 : word := B#(  2,  3);	//  010146 ( 02512 )
	D_609 : word := 2#0000000000000100;	// ME TEMP CALENTADOR CAMISAS 1
	D_610 : real := +0.0;
	D_611 : word := 2#0000000000000000;
	D_612 : int  := +00000;
	D_613 : int  := +00000;
	D_614 : int  := +00000;
	D_615 : word := B#(  0, 0);
	D_616 : word := B#(000,000);
	D_617 : word := 2#0000000000000000;
	D_618 : int  := +00000;
	D_619 : int  := +00000;
	D_620 : word := B#(  1,  1);	// State (1)
	D_621 : word := B#(  0,  1);	//
	D_622 : word := B#(  3,  4);	//
	D_623 : int  := +00000;	//
	D_624 : word := 2#0000000000000000;	//
	D_625 : word := B#(  0,  0);	//
	D_626 : word := B#(  1,  1);	// State (2)
	D_627 : word := B#(  0,  1);	//
	D_628 : word := B#(  1,  0);	//
	D_629 : int  := +00000;	//
	D_630 : word := 2#0000000000000000;	//
	D_631 : word := B#(  0,  0);	//
	D_632 : word := B#(  1,  1);	// State (3)
	D_633 : word := B#(  0,  0);	//
	D_634 : word := B#(  0,  0);	//
	D_635 : int  := +00000;	//
	D_636 : word := 2#0000000000000000;	//
	D_637 : word := B#(  0,  0);	//
	D_638 : word := B#(  1,  1);	// State (16)
	D_639 : word := B#(  0,  1);	//
	D_640 : word := B#(  15,  12);	//
	D_641 : int  := +00000;	//
	D_642 : word := 2#0000000000000000;	//
	D_643 : word := B#(  0,  0);	//
	D_644 : real := 0.000000000000;	//
	D_645 : real := 300.000000000000;	//
	D_646 : real := 0.000000000000;	//
	D_647 : real := 1.500000000000;	//
	D_648 : real := +0.0;	//
	D_649 : int  := 00000;	//
	D_650 : int  := 00000;	//
	D_651 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_652 : int  := 00000;	//
	D_653 : int  := +00000;	//
	D_654 : word  := B#(000,000);	//
	D_655 : int  := +00000;	//
	D_656 : real := 228.000000000000;	// Limit (1)
	D_657 : real := +0.0;	//
	D_658 : int  := +00000;	//
	D_659 : word := 2#0000000000000000;	//
	D_660 : int := +00000;	//
	D_661 : real := 217.000000000000;	// Limit (2)
	D_662 : real := +0.0;	//
	D_663 : int  := +00000;	//
	D_664 : word := 2#0000000000000000;	//
	D_665 : int := +00000;	//
	D_666 : word := B#(  2,  3);	//  010147 ( 02513 )
	D_667 : word := 2#0000000000000100;	// ME TEMP CALENTADOR CAMISAS 2
	D_668 : real := +0.0;
	D_669 : word := 2#0000000000000000;
	D_670 : int  := +00000;
	D_671 : int  := +00000;
	D_672 : int  := +00000;
	D_673 : word := B#(  0, 0);
	D_674 : word := B#(000,000);
	D_675 : word := 2#0000000000000000;
	D_676 : int  := +00000;
	D_677 : int  := +00000;
	D_678 : word := B#(  1,  1);	// State (1)
	D_679 : word := B#(  0,  1);	//
	D_680 : word := B#(  3,  4);	//
	D_681 : int  := +00000;	//
	D_682 : word := 2#0000000000000000;	//
	D_683 : word := B#(  0,  0);	//
	D_684 : word := B#(  1,  1);	// State (2)
	D_685 : word := B#(  0,  1);	//
	D_686 : word := B#(  1,  0);	//
	D_687 : int  := +00000;	//
	D_688 : word := 2#0000000000000000;	//
	D_689 : word := B#(  0,  0);	//
	D_690 : word := B#(  1,  1);	// State (3)
	D_691 : word := B#(  0,  0);	//
	D_692 : word := B#(  0,  0);	//
	D_693 : int  := +00000;	//
	D_694 : word := 2#0000000000000000;	//
	D_695 : word := B#(  0,  0);	//
	D_696 : word := B#(  1,  1);	// State (16)
	D_697 : word := B#(  0,  1);	//
	D_698 : word := B#(  15,  12);	//
	D_699 : int  := +00000;	//
	D_700 : word := 2#0000000000000000;	//
	D_701 : word := B#(  0,  0);	//
	D_702 : real := 0.000000000000;	//
	D_703 : real := 300.000000000000;	//
	D_704 : real := 0.000000000000;	//
	D_705 : real := 1.500000000000;	//
	D_706 : real := +0.0;	//
	D_707 : int  := 00000;	//
	D_708 : int  := 00000;	//
	D_709 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_710 : int  := 00000;	//
	D_711 : int  := +00000;	//
	D_712 : word  := B#(000,000);	//
	D_713 : int  := +00000;	//
	D_714 : real := 228.000000000000;	// Limit (1)
	D_715 : real := +0.0;	//
	D_716 : int  := +00000;	//
	D_717 : word := 2#0000000000000000;	//
	D_718 : int := +00000;	//
	D_719 : real := 217.000000000000;	// Limit (2)
	D_720 : real := +0.0;	//
	D_721 : int  := +00000;	//
	D_722 : word := 2#0000000000000000;	//
	D_723 : int := +00000;	//
	D_724 : word := B#(  2,  2);	//  010148 ( 02514 )
	D_725 : word := 2#0000000000000100;	// ME TEMP AGUA DE ENTRADA AC/OC
	D_726 : real := +0.0;
	D_727 : word := 2#0000000000000000;
	D_728 : int  := +00000;
	D_729 : int  := +00000;
	D_730 : int  := +00000;
	D_731 : word := B#(  0, 0);
	D_732 : word := B#(000,000);
	D_733 : word := 2#0000000000000000;
	D_734 : int  := +00000;
	D_735 : int  := +00000;
	D_736 : word := B#(  1,  1);	// State (1)
	D_737 : word := B#(  0,  1);	//
	D_738 : word := B#(  5,  8);	//
	D_739 : int  := +00000;	//
	D_740 : word := 2#0000000000000000;	//
	D_741 : word := B#(  0,  0);	//
	D_742 : word := B#(  1,  1);	// State (2)
	D_743 : word := B#(  0,  0);	//
	D_744 : word := B#(  0,  0);	//
	D_745 : int  := +00000;	//
	D_746 : word := 2#0000000000000000;	//
	D_747 : word := B#(  0,  0);	//
	D_748 : word := B#(  1,  1);	// State (16)
	D_749 : word := B#(  0,  1);	//
	D_750 : word := B#(  15,  12);	//
	D_751 : int  := +00000;	//
	D_752 : word := 2#0000000000000000;	//
	D_753 : word := B#(  0,  0);	//
	D_754 : real := 0.000000000000;	//
	D_755 : real := 300.000000000000;	//
	D_756 : real := 0.000000000000;	//
	D_757 : real := 1.500000000000;	//
	D_758 : real := +0.0;	//
	D_759 : int  := 00000;	//
	D_760 : int  := 00000;	//
	D_761 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_762 : int  := 00000;	//
	D_763 : int  := +00000;	//
	D_764 : word  := B#(000,000);	//
	D_765 : int  := +00000;	//
	D_766 : real := 140.000000000000;	// Limit (1)
	D_767 : real := +0.0;	//
	D_768 : int  := +00000;	//
	D_769 : word := 2#0000000000000000;	//
	D_770 : int := +00000;	//
	D_771 : word := B#(  2,  3);	//  010149 ( 02515 )
	D_772 : word := 2#0000000000000100;	// ME TEMP CUARTO DE MAQUINAS B1
	D_773 : real := +0.0;
	D_774 : word := 2#0000000000000000;
	D_775 : int  := +00000;
	D_776 : int  := +00000;
	D_777 : int  := +00000;
	D_778 : word := B#(  0, 0);
	D_779 : word := B#(000,000);
	D_780 : word := 2#0000000000000000;
	D_781 : int  := +00000;
	D_782 : int  := +00000;
	D_783 : word := B#(  1,  1);	// State (1)
	D_784 : word := B#(  0,  1);	//
	D_785 : word := B#(  5,  8);	//
	D_786 : int  := +00000;	//
	D_787 : word := 2#0000000000000000;	//
	D_788 : word := B#(  0,  0);	//
	D_789 : word := B#(  1,  1);	// State (2)
	D_790 : word := B#(  0,  1);	//
	D_791 : word := B#(  3,  4);	//
	D_792 : int  := +00000;	//
	D_793 : word := 2#0000000000000000;	//
	D_794 : word := B#(  0,  0);	//
	D_795 : word := B#(  1,  1);	// State (3)
	D_796 : word := B#(  0,  0);	//
	D_797 : word := B#(  0,  0);	//
	D_798 : int  := +00000;	//
	D_799 : word := 2#0000000000000000;	//
	D_800 : word := B#(  0,  0);	//
	D_801 : word := B#(  1,  1);	// State (16)
	D_802 : word := B#(  0,  1);	//
	D_803 : word := B#(  15,  12);	//
	D_804 : int  := +00000;	//
	D_805 : word := 2#0000000000000000;	//
	D_806 : word := B#(  0,  0);	//
	D_807 : real := 32.000000000000;	//
	D_808 : real := 212.000000000000;	//
	D_809 : real := 0.900000000000;	//
	D_810 : real := 0.900000000000;	//
	D_811 : real := +0.0;	//
	D_812 : int  := 00000;	//
	D_813 : int  := 00000;	//
	D_814 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_815 : int  := 00000;	//
	D_816 : int  := +00000;	//
	D_817 : word  := B#(000,000);	//
	D_818 : int  := +00000;	//
	D_819 : real := 122.000000000000;	// Limit (1)
	D_820 : real := +0.0;	//
	D_821 : int  := +00000;	//
	D_822 : word := 2#0000000000000000;	//
	D_823 : int := +00000;	//
	D_824 : real := 104.000000000000;	// Limit (2)
	D_825 : real := +0.0;	//
	D_826 : int  := +00000;	//
	D_827 : word := 2#0000000000000000;	//
	D_828 : int := +00000;	//
	D_829 : word := B#(  2,  2);	//  010150 ( 02516 )
	D_830 : word := 2#0000000000000100;	// ME VELOCIDAD DEL MOTOR RPM
	D_831 : real := +0.0;
	D_832 : word := 2#0000000000000000;
	D_833 : int  := +00000;
	D_834 : int  := +00000;
	D_835 : int  := +00000;
	D_836 : word := B#(  0, 0);
	D_837 : word := B#(000,000);
	D_838 : word := 2#0000000000000000;
	D_839 : int  := +00000;
	D_840 : int  := +00000;
	D_841 : word := B#(  1,  1);	// State (1)
	D_842 : word := B#(  0,  1);	//
	D_843 : word := B#(  6,  0);	//
	D_844 : int  := +00000;	//
	D_845 : word := 2#0000000000000000;	//
	D_846 : word := B#(  0,  0);	//
	D_847 : word := B#(  1,  1);	// State (2)
	D_848 : word := B#(  0,  0);	//
	D_849 : word := B#(  0,  0);	//
	D_850 : int  := +00000;	//
	D_851 : word := 2#0000000000000000;	//
	D_852 : word := B#(  0,  0);	//
	D_853 : word := B#(  1,  1);	// State (16)
	D_854 : word := B#(  0,  1);	//
	D_855 : word := B#(  15,  12);	//
	D_856 : int  := +00000;	//
	D_857 : word := 2#0000000000000000;	//
	D_858 : word := B#(  0,  0);	//
	D_859 : real := 0.000000000000;	//
	D_860 : real := 1500.000000000000;	//
	D_861 : real := 15.000000000000;	//
	D_862 : real := 15.000000000000;	//
	D_863 : real := +0.0;	//
	D_864 : int  := 00000;	//
	D_865 : int  := 00000;	//
	D_866 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_867 : int  := 00000;	//
	D_868 : int  := +00000;	//
	D_869 : word  := B#(000,000);	//
	D_870 : int  := +00000;	//
	D_871 : real := 1100.000000000000;	// Limit (1)
	D_872 : real := +0.0;	//
	D_873 : int  := +00000;	//
	D_874 : word := 2#0000000000000000;	//
	D_875 : int := +00000;	//
	D_876 : word := B#(  2,  3);	//  010151 ( 02517 )
	D_877 : word := 2#0000000000000100;	// ME TEMP SALIDA GASES TURBO IZQ
	D_878 : real := +0.0;
	D_879 : word := 2#0000000000000000;
	D_880 : int  := +00000;
	D_881 : int  := +00000;
	D_882 : int  := +00000;
	D_883 : word := B#(  0, 0);
	D_884 : word := B#(000,000);
	D_885 : word := 2#0000000000000000;
	D_886 : int  := +00000;
	D_887 : int  := +00000;
	D_888 : word := B#(  1,  1);	// State (1)
	D_889 : word := B#(  0,  1);	//
	D_890 : word := B#(  5,  8);	//
	D_891 : int  := +00000;	//
	D_892 : word := 2#0000000000000000;	//
	D_893 : word := B#(  0,  0);	//
	D_894 : word := B#(  1,  1);	// State (2)
	D_895 : word := B#(  0,  1);	//
	D_896 : word := B#(  3,  4);	//
	D_897 : int  := +00000;	//
	D_898 : word := 2#0000000000000000;	//
	D_899 : word := B#(  0,  0);	//
	D_900 : word := B#(  1,  1);	// State (3)
	D_901 : word := B#(  0,  0);	//
	D_902 : word := B#(  0,  0);	//
	D_903 : int  := +00000;	//
	D_904 : word := 2#0000000000000000;	//
	D_905 : word := B#(  0,  0);	//
	D_906 : word := B#(  1,  1);	// State (16)
	D_907 : word := B#(  0,  1);	//
	D_908 : word := B#(  15,  12);	//
	D_909 : int  := +00000;	//
	D_910 : word := 2#0000000000000000;	//
	D_911 : word := B#(  0,  0);	//
	D_912 : real := 0.000000000000;	//
	D_913 : real := 1300.000000000000;	//
	D_914 : real := 0.000000000000;	//
	D_915 : real := 6.500000000000;	//
	D_916 : real := +0.0;	//
	D_917 : int  := 00000;	//
	D_918 : int  := 00000;	//
	D_919 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_920 : int  := 00000;	//
	D_921 : int  := +00000;	//
	D_922 : word  := B#(000,000);	//
	D_923 : int  := +00000;	//
	D_924 : real := 1094.000000000000;	// Limit (1)
	D_925 : real := +0.0;	//
	D_926 : int  := +00000;	//
	D_927 : word := 2#0000000000000000;	//
	D_928 : int := +00000;	//
	D_929 : real := 1022.000000000000;	// Limit (2)
	D_930 : real := +0.0;	//
	D_931 : int  := +00000;	//
	D_932 : word := 2#0000000000000000;	//
	D_933 : int := +00000;	//
	D_934 : word := B#(  2,  3);	//  010152 ( 02518 )
	D_935 : word := 2#0000000000000100;	// ME TEMP SALIDA GASES TURBO DER
	D_936 : real := +0.0;
	D_937 : word := 2#0000000000000000;
	D_938 : int  := +00000;
	D_939 : int  := +00000;
	D_940 : int  := +00000;
	D_941 : word := B#(  0, 0);
	D_942 : word := B#(000,000);
	D_943 : word := 2#0000000000000000;
	D_944 : int  := +00000;
	D_945 : int  := +00000;
	D_946 : word := B#(  1,  1);	// State (1)
	D_947 : word := B#(  0,  1);	//
	D_948 : word := B#(  5,  8);	//
	D_949 : int  := +00000;	//
	D_950 : word := 2#0000000000000000;	//
	D_951 : word := B#(  0,  0);	//
	D_952 : word := B#(  1,  1);	// State (2)
	D_953 : word := B#(  0,  1);	//
	D_954 : word := B#(  3,  4);	//
	D_955 : int  := +00000;	//
	D_956 : word := 2#0000000000000000;	//
	D_957 : word := B#(  0,  0);	//
	D_958 : word := B#(  1,  1);	// State (3)
	D_959 : word := B#(  0,  0);	//
	D_960 : word := B#(  0,  0);	//
	D_961 : int  := +00000;	//
	D_962 : word := 2#0000000000000000;	//
	D_963 : word := B#(  0,  0);	//
	D_964 : word := B#(  1,  1);	// State (16)
	D_965 : word := B#(  0,  1);	//
	D_966 : word := B#(  15,  12);	//
	D_967 : int  := +00000;	//
	D_968 : word := 2#0000000000000000;	//
	D_969 : word := B#(  0,  0);	//
	D_970 : real := 0.000000000000;	//
	D_971 : real := 1300.000000000000;	//
	D_972 : real := 0.000000000000;	//
	D_973 : real := 6.500000000000;	//
	D_974 : real := +0.0;	//
	D_975 : int  := 00000;	//
	D_976 : int  := 00000;	//
	D_977 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_978 : int  := 00000;	//
	D_979 : int  := +00000;	//
	D_980 : word  := B#(000,000);	//
	D_981 : int  := +00000;	//
	D_982 : real := 1110.000000000000;	// Limit (1)
	D_983 : real := +0.0;	//
	D_984 : int  := +00000;	//
	D_985 : word := 2#0000000000000000;	//
	D_986 : int := +00000;	//
	D_987 : real := 1020.000000000000;	// Limit (2)
	D_988 : real := +0.0;	//
	D_989 : int  := +00000;	//
	D_990 : word := 2#0000000000000000;	//
	D_991 : int := +00000;	//
	D_992 : word := B#(  2,  2);	//  010153 ( 02519 )
	D_993 : word := 2#0000000000000100;	// ME TEMP GASES ENT TURBO IZQ
	D_994 : real := +0.0;
	D_995 : word := 2#0000000000000000;
	D_996 : int  := +00000;
	D_997 : int  := +00000;
	D_998 : int  := +00000;
	D_999 : word := B#(  0, 0);
	D_1000 : word := B#(000,000);
	D_1001 : word := 2#0000000000000000;
	D_1002 : int  := +00000;
	D_1003 : int  := +00000;
	D_1004 : word := B#(  1,  1);	// State (1)
	D_1005 : word := B#(  0,  1);	//
	D_1006 : word := B#(  1,  0);	//
	D_1007 : int  := +00000;	//
	D_1008 : word := 2#0000000000000000;	//
	D_1009 : word := B#(  0,  0);	//
	D_1010 : word := B#(  1,  1);	// State (2)
	D_1011 : word := B#(  0,  0);	//
	D_1012 : word := B#(  0,  0);	//
	D_1013 : int  := +00000;	//
	D_1014 : word := 2#0000000000000000;	//
	D_1015 : word := B#(  0,  0);	//
	D_1016 : word := B#(  1,  1);	// State (16)
	D_1017 : word := B#(  0,  1);	//
	D_1018 : word := B#(  15,  12);	//
	D_1019 : int  := +00000;	//
	D_1020 : word := 2#0000000000000000;	//
	D_1021 : word := B#(  0,  0);	//
	D_1022 : real := 0.000000000000;	//
	D_1023 : real := 1500.000000000000;	//
	D_1024 : real := 0.000000000000;	//
	D_1025 : real := 7.500000000000;	//
	D_1026 : real := +0.0;	//
	D_1027 : int  := 00000;	//
	D_1028 : int  := 00000;	//
	D_1029 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_1030 : int  := 00000;	//
	D_1031 : int  := +00000;	//
	D_1032 : word  := B#(000,000);	//
	D_1033 : int  := +00000;	//
	D_1034 : real := 1166.000000000000;	// Limit (1)
	D_1035 : real := +0.0;	//
	D_1036 : int  := +00000;	//
	D_1037 : word := 2#0000000000000000;	//
	D_1038 : int := +00000;	//
	D_1039 : word := B#(  2,  2);	//  010154 ( 02520 )
	D_1040 : word := 2#0000000000000100;	// ME TEMP GASES ENT TURBO DER
	D_1041 : real := +0.0;
	D_1042 : word := 2#0000000000000000;
	D_1043 : int  := +00000;
	D_1044 : int  := +00000;
	D_1045 : int  := +00000;
	D_1046 : word := B#(  0, 0);
	D_1047 : word := B#(000,000);
	D_1048 : word := 2#0000000000000000;
	D_1049 : int  := +00000;
	D_1050 : int  := +00000;
	D_1051 : word := B#(  1,  1);	// State (1)
	D_1052 : word := B#(  0,  1);	//
	D_1053 : word := B#(  3,  4);	//
	D_1054 : int  := +00000;	//
	D_1055 : word := 2#0000000000000000;	//
	D_1056 : word := B#(  0,  0);	//
	D_1057 : word := B#(  1,  1);	// State (2)
	D_1058 : word := B#(  0,  0);	//
	D_1059 : word := B#(  0,  0);	//
	D_1060 : int  := +00000;	//
	D_1061 : word := 2#0000000000000000;	//
	D_1062 : word := B#(  0,  0);	//
	D_1063 : word := B#(  1,  1);	// State (16)
	D_1064 : word := B#(  0,  1);	//
	D_1065 : word := B#(  15,  12);	//
	D_1066 : int  := +00000;	//
	D_1067 : word := 2#0000000000000000;	//
	D_1068 : word := B#(  0,  0);	//
	D_1069 : real := 0.000000000000;	//
	D_1070 : real := 1500.000000000000;	//
	D_1071 : real := 0.000000000000;	//
	D_1072 : real := 7.500000000000;	//
	D_1073 : real := +0.0;	//
	D_1074 : int  := 00000;	//
	D_1075 : int  := 00000;	//
	D_1076 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_1077 : int  := 00000;	//
	D_1078 : int  := +00000;	//
	D_1079 : word  := B#(000,000);	//
	D_1080 : int  := +00000;	//
	D_1081 : real := 1166.000000000000;	// Limit (1)
	D_1082 : real := +0.0;	//
	D_1083 : int  := +00000;	//
	D_1084 : word := 2#0000000000000000;	//
	D_1085 : int := +00000;	//
	D_1086 : word := B#(  2,  3);	//  010155 ( 02521 )
	D_1087 : word := 2#0000000000000100;	// ME TEMP CILINDRO 1
	D_1088 : real := +0.0;
	D_1089 : word := 2#0000000000000000;
	D_1090 : int  := +00001;
	D_1091 : int  := +00000;
	D_1092 : int  := +00000;
	D_1093 : word := B#(  0, 0);
	D_1094 : word := B#(000,000);
	D_1095 : word := 2#0000000000000000;
	D_1096 : int  := +00000;
	D_1097 : int  := +00000;
	D_1098 : word := B#(  1,  1);	// State (1)
	D_1099 : word := B#(  0,  1);	//
	D_1100 : word := B#(  5,  8);	//
	D_1101 : int  := +00200;	//
	D_1102 : word := 2#0000000000000000;	//
	D_1103 : word := B#(  0,  0);	//
	D_1104 : word := B#(  1,  1);	// State (2)
	D_1105 : word := B#(  0,  1);	//
	D_1106 : word := B#(  3,  4);	//
	D_1107 : int  := +00000;	//
	D_1108 : word := 2#0000000000000000;	//
	D_1109 : word := B#(  0,  0);	//
	D_1110 : word := B#(  1,  1);	// State (3)
	D_1111 : word := B#(  0,  0);	//
	D_1112 : word := B#(  0,  0);	//
	D_1113 : int  := +00000;	//
	D_1114 : word := 2#0000000000000000;	//
	D_1115 : word := B#(  0,  0);	//
	D_1116 : word := B#(  1,  1);	// State (16)
	D_1117 : word := B#(  0,  1);	//
	D_1118 : word := B#(  15,  12);	//
	D_1119 : int  := +00000;	//
	D_1120 : word := 2#0000000000000000;	//
	D_1121 : word := B#(  0,  0);	//
	D_1122 : real := 0.000000000000;	//
	D_1123 : real := 1300.000000000000;	//
	D_1124 : real := 0.000000000000;	//
	D_1125 : real := 0.000000000000;	//
	D_1126 : real := +0.0;	//
	D_1127 : int  := 00000;	//
	D_1128 : int  := 00000;	//
	D_1129 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_1130 : int  := 00000;	//
	D_1131 : int  := +00000;	//
	D_1132 : word  := B#(000,000);	//
	D_1133 : int  := +00000;	//
	D_1134 : real := 1110.000000000000;	// Limit (1)
	D_1135 : real := +0.0;	//
	D_1136 : int  := +00000;	//
	D_1137 : word := 2#0000000000000000;	//
	D_1138 : int := +00000;	//
	D_1139 : real := 1022.000000000000;	// Limit (2)
	D_1140 : real := +0.0;	//
	D_1141 : int  := +00000;	//
	D_1142 : word := 2#0000000000000000;	//
	D_1143 : int := +00000;	//
	D_1144 : word := B#(  2,  3);	//  010155D ( 02522 )
	D_1145 : word := 2#0000000000000100;	// ME CILINDRO TEMP 1 DESV.
	D_1146 : real := +0.0;
	D_1147 : word := 2#0000000000000000;
	D_1148 : int  := +00001;
	D_1149 : int  := +00000;
	D_1150 : int  := +00000;
	D_1151 : word := B#(  0, 0);
	D_1152 : word := B#(000,000);
	D_1153 : word := 2#0000000000000000;
	D_1154 : int  := +00000;
	D_1155 : int  := +00000;
	D_1156 : word := B#(  1,  1);	// State (1)
	D_1157 : word := B#(  0,  1);	//
	D_1158 : word := B#(  5,  8);	//
	D_1159 : int  := +00200;	//
	D_1160 : word := 2#0000000000000000;	//
	D_1161 : word := B#(  0,  0);	//
	D_1162 : word := B#(  1,  1);	// State (2)
	D_1163 : word := B#(  0,  0);	//
	D_1164 : word := B#(  0,  0);	//
	D_1165 : int  := +00000;	//
	D_1166 : word := 2#0000000000000000;	//
	D_1167 : word := B#(  0,  0);	//
	D_1168 : word := B#(  1,  1);	// State (3)
	D_1169 : word := B#(  0,  1);	//
	D_1170 : word := B#(  6,  1);	//
	D_1171 : int  := +00000;	//
	D_1172 : word := 2#0000000000000000;	//
	D_1173 : word := B#(  0,  0);	//
	D_1174 : word := B#(  1,  1);	// State (16)
	D_1175 : word := B#(  0,  1);	//
	D_1176 : word := B#(  15,  12);	//
	D_1177 : int  := +00000;	//
	D_1178 : word := 2#0000000000000000;	//
	D_1179 : word := B#(  0,  0);	//
	D_1180 : real := -150.000000000000;	//
	D_1181 : real := 150.000000000000;	//
	D_1182 : real := 0.000000000000;	//
	D_1183 : real := 1.500000000000;	//
	D_1184 : real := +0.0;	//
	D_1185 : int  := 00000;	//
	D_1186 : int  := 00000;	//
	D_1187 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_1188 : int  := 00000;	//
	D_1189 : int  := +00000;	//
	D_1190 : word  := B#(000,000);	//
	D_1191 : int  := +00000;	//
	D_1192 : real := 120.000000000000;	// Limit (1)
	D_1193 : real := +0.0;	//
	D_1194 : int  := +00000;	//
	D_1195 : word := 2#0000000000000000;	//
	D_1196 : int := +00000;	//
	D_1197 : real := -120.000000000000;	// Limit (2)
	D_1198 : real := +0.0;	//
	D_1199 : int  := +00000;	//
	D_1200 : word := 2#0000000000000000;	//
	D_1201 : int := +00000;	//
	D_1202 : word := B#(  2,  3);	//  010156 ( 02523 )
	D_1203 : word := 2#0000000000000100;	// ME TEMP CILINDRO 2
	D_1204 : real := +0.0;
	D_1205 : word := 2#0000000000000000;
	D_1206 : int  := +00001;
	D_1207 : int  := +00000;
	D_1208 : int  := +00000;
	D_1209 : word := B#(  0, 0);
	D_1210 : word := B#(000,000);
	D_1211 : word := 2#0000000000000000;
	D_1212 : int  := +00000;
	D_1213 : int  := +00000;
	D_1214 : word := B#(  1,  1);	// State (1)
	D_1215 : word := B#(  0,  1);	//
	D_1216 : word := B#(  5,  8);	//
	D_1217 : int  := +00200;	//
	D_1218 : word := 2#0000000000000000;	//
	D_1219 : word := B#(  0,  0);	//
	D_1220 : word := B#(  1,  1);	// State (2)
	D_1221 : word := B#(  0,  1);	//
	D_1222 : word := B#(  3,  4);	//
	D_1223 : int  := +00000;	//
	D_1224 : word := 2#0000000000000000;	//
	D_1225 : word := B#(  0,  0);	//
	D_1226 : word := B#(  1,  1);	// State (3)
	D_1227 : word := B#(  0,  0);	//
	D_1228 : word := B#(  0,  0);	//
	D_1229 : int  := +00000;	//
	D_1230 : word := 2#0000000000000000;	//
	D_1231 : word := B#(  0,  0);	//
	D_1232 : word := B#(  1,  1);	// State (16)
	D_1233 : word := B#(  0,  1);	//
	D_1234 : word := B#(  15,  12);	//
	D_1235 : int  := +00000;	//
	D_1236 : word := 2#0000000000000000;	//
	D_1237 : word := B#(  0,  0);	//
	D_1238 : real := 0.000000000000;	//
	D_1239 : real := 1300.000000000000;	//
	D_1240 : real := 0.000000000000;	//
	D_1241 : real := 0.000000000000;	//
	D_1242 : real := +0.0;	//
	D_1243 : int  := 00000;	//
	D_1244 : int  := 00000;	//
	D_1245 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_1246 : int  := 00000;	//
	D_1247 : int  := +00000;	//
	D_1248 : word  := B#(000,000);	//
	D_1249 : int  := +00000;	//
	D_1250 : real := 1110.000000000000;	// Limit (1)
	D_1251 : real := +0.0;	//
	D_1252 : int  := +00000;	//
	D_1253 : word := 2#0000000000000000;	//
	D_1254 : int := +00000;	//
	D_1255 : real := 1022.000000000000;	// Limit (2)
	D_1256 : real := +0.0;	//
	D_1257 : int  := +00000;	//
	D_1258 : word := 2#0000000000000000;	//
	D_1259 : int := +00000;	//
	D_1260 : word := B#(  2,  3);	//  010156D ( 02524 )
	D_1261 : word := 2#0000000000000100;	// ME CILINDRO TEMP 2 DESV.
	D_1262 : real := +0.0;
	D_1263 : word := 2#0000000000000000;
	D_1264 : int  := +00001;
	D_1265 : int  := +00000;
	D_1266 : int  := +00000;
	D_1267 : word := B#(  0, 0);
	D_1268 : word := B#(000,000);
	D_1269 : word := 2#0000000000000000;
	D_1270 : int  := +00000;
	D_1271 : int  := +00000;
	D_1272 : word := B#(  1,  1);	// State (1)
	D_1273 : word := B#(  0,  1);	//
	D_1274 : word := B#(  5,  8);	//
	D_1275 : int  := +00200;	//
	D_1276 : word := 2#0000000000000000;	//
	D_1277 : word := B#(  0,  0);	//
	D_1278 : word := B#(  1,  1);	// State (2)
	D_1279 : word := B#(  0,  0);	//
	D_1280 : word := B#(  0,  0);	//
	D_1281 : int  := +00000;	//
	D_1282 : word := 2#0000000000000000;	//
	D_1283 : word := B#(  0,  0);	//
	D_1284 : word := B#(  1,  1);	// State (3)
	D_1285 : word := B#(  0,  1);	//
	D_1286 : word := B#(  6,  1);	//
	D_1287 : int  := +00000;	//
	D_1288 : word := 2#0000000000000000;	//
	D_1289 : word := B#(  0,  0);	//
	D_1290 : word := B#(  1,  1);	// State (16)
	D_1291 : word := B#(  0,  1);	//
	D_1292 : word := B#(  15,  12);	//
	D_1293 : int  := +00000;	//
	D_1294 : word := 2#0000000000000000;	//
	D_1295 : word := B#(  0,  0);	//
	D_1296 : real := -150.000000000000;	//
	D_1297 : real := 150.000000000000;	//
	D_1298 : real := 0.000000000000;	//
	D_1299 : real := 1.500000000000;	//
	D_1300 : real := +0.0;	//
	D_1301 : int  := 00000;	//
	D_1302 : int  := 00000;	//
	D_1303 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_1304 : int  := 00000;	//
	D_1305 : int  := +00000;	//
	D_1306 : word  := B#(000,000);	//
	D_1307 : int  := +00000;	//
	D_1308 : real := 120.000000000000;	// Limit (1)
	D_1309 : real := +0.0;	//
	D_1310 : int  := +00000;	//
	D_1311 : word := 2#0000000000000000;	//
	D_1312 : int := +00000;	//
	D_1313 : real := -120.000000000000;	// Limit (2)
	D_1314 : real := +0.0;	//
	D_1315 : int  := +00000;	//
	D_1316 : word := 2#0000000000000000;	//
	D_1317 : int := +00000;	//
	D_1318 : word := B#(  2,  3);	//  010157 ( 02525 )
	D_1319 : word := 2#0000000000000100;	// ME TEMP CILINDRO 3
	D_1320 : real := +0.0;
	D_1321 : word := 2#0000000000000000;
	D_1322 : int  := +00001;
	D_1323 : int  := +00000;
	D_1324 : int  := +00000;
	D_1325 : word := B#(  0, 0);
	D_1326 : word := B#(000,000);
	D_1327 : word := 2#0000000000000000;
	D_1328 : int  := +00000;
	D_1329 : int  := +00000;
	D_1330 : word := B#(  1,  1);	// State (1)
	D_1331 : word := B#(  0,  1);	//
	D_1332 : word := B#(  5,  8);	//
	D_1333 : int  := +00200;	//
	D_1334 : word := 2#0000000000000000;	//
	D_1335 : word := B#(  0,  0);	//
	D_1336 : word := B#(  1,  1);	// State (2)
	D_1337 : word := B#(  0,  1);	//
	D_1338 : word := B#(  3,  4);	//
	D_1339 : int  := +00000;	//
	D_1340 : word := 2#0000000000000000;	//
	D_1341 : word := B#(  0,  0);	//
	D_1342 : word := B#(  1,  1);	// State (3)
	D_1343 : word := B#(  0,  0);	//
	D_1344 : word := B#(  0,  0);	//
	D_1345 : int  := +00000;	//
	D_1346 : word := 2#0000000000000000;	//
	D_1347 : word := B#(  0,  0);	//
	D_1348 : word := B#(  1,  1);	// State (16)
	D_1349 : word := B#(  0,  1);	//
	D_1350 : word := B#(  15,  12);	//
	D_1351 : int  := +00000;	//
	D_1352 : word := 2#0000000000000000;	//
	D_1353 : word := B#(  0,  0);	//
	D_1354 : real := 0.000000000000;	//
	D_1355 : real := 1300.000000000000;	//
	D_1356 : real := 0.000000000000;	//
	D_1357 : real := 0.000000000000;	//
	D_1358 : real := +0.0;	//
	D_1359 : int  := 00000;	//
	D_1360 : int  := 00000;	//
	D_1361 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_1362 : int  := 00000;	//
	D_1363 : int  := +00000;	//
	D_1364 : word  := B#(000,000);	//
	D_1365 : int  := +00000;	//
	D_1366 : real := 1110.000000000000;	// Limit (1)
	D_1367 : real := +0.0;	//
	D_1368 : int  := +00000;	//
	D_1369 : word := 2#0000000000000000;	//
	D_1370 : int := +00000;	//
	D_1371 : real := 1022.000000000000;	// Limit (2)
	D_1372 : real := +0.0;	//
	D_1373 : int  := +00000;	//
	D_1374 : word := 2#0000000000000000;	//
	D_1375 : int := +00000;	//
	D_1376 : word := B#(  2,  3);	//  010157D ( 02526 )
	D_1377 : word := 2#0000000000000100;	// ME CILINDRO TEMP 3 DESV.
	D_1378 : real := +0.0;
	D_1379 : word := 2#0000000000000000;
	D_1380 : int  := +00001;
	D_1381 : int  := +00000;
	D_1382 : int  := +00000;
	D_1383 : word := B#(  0, 0);
	D_1384 : word := B#(000,000);
	D_1385 : word := 2#0000000000000000;
	D_1386 : int  := +00000;
	D_1387 : int  := +00000;
	D_1388 : word := B#(  1,  1);	// State (1)
	D_1389 : word := B#(  0,  1);	//
	D_1390 : word := B#(  5,  8);	//
	D_1391 : int  := +00200;	//
	D_1392 : word := 2#0000000000000000;	//
	D_1393 : word := B#(  0,  0);	//
	D_1394 : word := B#(  1,  1);	// State (2)
	D_1395 : word := B#(  0,  0);	//
	D_1396 : word := B#(  0,  0);	//
	D_1397 : int  := +00000;	//
	D_1398 : word := 2#0000000000000000;	//
	D_1399 : word := B#(  0,  0);	//
	D_1400 : word := B#(  1,  1);	// State (3)
	D_1401 : word := B#(  0,  1);	//
	D_1402 : word := B#(  6,  1);	//
	D_1403 : int  := +00000;	//
	D_1404 : word := 2#0000000000000000;	//
	D_1405 : word := B#(  0,  0);	//
	D_1406 : word := B#(  1,  1);	// State (16)
	D_1407 : word := B#(  0,  1);	//
	D_1408 : word := B#(  15,  12);	//
	D_1409 : int  := +00000;	//
	D_1410 : word := 2#0000000000000000;	//
	D_1411 : word := B#(  0,  0);	//
	D_1412 : real := -150.000000000000;	//
	D_1413 : real := 150.000000000000;	//
	D_1414 : real := 0.000000000000;	//
	D_1415 : real := 1.500000000000;	//
	D_1416 : real := +0.0;	//
	D_1417 : int  := 00000;	//
	D_1418 : int  := 00000;	//
	D_1419 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_1420 : int  := 00000;	//
	D_1421 : int  := +00000;	//
	D_1422 : word  := B#(000,000);	//
	D_1423 : int  := +00000;	//
	D_1424 : real := 120.000000000000;	// Limit (1)
	D_1425 : real := +0.0;	//
	D_1426 : int  := +00000;	//
	D_1427 : word := 2#0000000000000000;	//
	D_1428 : int := +00000;	//
	D_1429 : real := -120.000000000000;	// Limit (2)
	D_1430 : real := +0.0;	//
	D_1431 : int  := +00000;	//
	D_1432 : word := 2#0000000000000000;	//
	D_1433 : int := +00000;	//
	D_1434 : word := B#(  2,  3);	//  010158 ( 02527 )
	D_1435 : word := 2#0000000000000100;	// ME TEMP CILINDRO 4
	D_1436 : real := +0.0;
	D_1437 : word := 2#0000000000000000;
	D_1438 : int  := +00001;
	D_1439 : int  := +00000;
	D_1440 : int  := +00000;
	D_1441 : word := B#(  0, 0);
	D_1442 : word := B#(000,000);
	D_1443 : word := 2#0000000000000000;
	D_1444 : int  := +00000;
	D_1445 : int  := +00000;
	D_1446 : word := B#(  1,  1);	// State (1)
	D_1447 : word := B#(  0,  1);	//
	D_1448 : word := B#(  5,  8);	//
	D_1449 : int  := +00200;	//
	D_1450 : word := 2#0000000000000000;	//
	D_1451 : word := B#(  0,  0);	//
	D_1452 : word := B#(  1,  1);	// State (2)
	D_1453 : word := B#(  0,  1);	//
	D_1454 : word := B#(  3,  4);	//
	D_1455 : int  := +00000;	//
	D_1456 : word := 2#0000000000000000;	//
	D_1457 : word := B#(  0,  0);	//
	D_1458 : word := B#(  1,  1);	// State (3)
	D_1459 : word := B#(  0,  0);	//
	D_1460 : word := B#(  0,  0);	//
	D_1461 : int  := +00000;	//
	D_1462 : word := 2#0000000000000000;	//
	D_1463 : word := B#(  0,  0);	//
	D_1464 : word := B#(  1,  1);	// State (16)
	D_1465 : word := B#(  0,  1);	//
	D_1466 : word := B#(  15,  12);	//
	D_1467 : int  := +00000;	//
	D_1468 : word := 2#0000000000000000;	//
	D_1469 : word := B#(  0,  0);	//
	D_1470 : real := 0.000000000000;	//
	D_1471 : real := 1300.000000000000;	//
	D_1472 : real := 0.000000000000;	//
	D_1473 : real := 0.000000000000;	//
	D_1474 : real := +0.0;	//
	D_1475 : int  := 00000;	//
	D_1476 : int  := 00000;	//
	D_1477 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_1478 : int  := 00000;	//
	D_1479 : int  := +00000;	//
	D_1480 : word  := B#(000,000);	//
	D_1481 : int  := +00000;	//
	D_1482 : real := 1110.000000000000;	// Limit (1)
	D_1483 : real := +0.0;	//
	D_1484 : int  := +00000;	//
	D_1485 : word := 2#0000000000000000;	//
	D_1486 : int := +00000;	//
	D_1487 : real := 1022.000000000000;	// Limit (2)
	D_1488 : real := +0.0;	//
	D_1489 : int  := +00000;	//
	D_1490 : word := 2#0000000000000000;	//
	D_1491 : int := +00000;	//
	D_1492 : word := B#(  2,  3);	//  010158D ( 02528 )
	D_1493 : word := 2#0000000000000100;	// ME  CILINDRO TEMP 4 DESV.
	D_1494 : real := +0.0;
	D_1495 : word := 2#0000000000000000;
	D_1496 : int  := +00001;
	D_1497 : int  := +00000;
	D_1498 : int  := +00000;
	D_1499 : word := B#(  0, 0);
	D_1500 : word := B#(000,000);
	D_1501 : word := 2#0000000000000000;
	D_1502 : int  := +00000;
	D_1503 : int  := +00000;
	D_1504 : word := B#(  1,  1);	// State (1)
	D_1505 : word := B#(  0,  1);	//
	D_1506 : word := B#(  5,  8);	//
	D_1507 : int  := +00200;	//
	D_1508 : word := 2#0000000000000000;	//
	D_1509 : word := B#(  0,  0);	//
	D_1510 : word := B#(  1,  1);	// State (2)
	D_1511 : word := B#(  0,  0);	//
	D_1512 : word := B#(  0,  0);	//
	D_1513 : int  := +00000;	//
	D_1514 : word := 2#0000000000000000;	//
	D_1515 : word := B#(  0,  0);	//
	D_1516 : word := B#(  1,  1);	// State (3)
	D_1517 : word := B#(  0,  1);	//
	D_1518 : word := B#(  6,  1);	//
	D_1519 : int  := +00000;	//
	D_1520 : word := 2#0000000000000000;	//
	D_1521 : word := B#(  0,  0);	//
	D_1522 : word := B#(  1,  1);	// State (16)
	D_1523 : word := B#(  0,  1);	//
	D_1524 : word := B#(  15,  12);	//
	D_1525 : int  := +00000;	//
	D_1526 : word := 2#0000000000000000;	//
	D_1527 : word := B#(  0,  0);	//
	D_1528 : real := -150.000000000000;	//
	D_1529 : real := 150.000000000000;	//
	D_1530 : real := 0.000000000000;	//
	D_1531 : real := 1.500000000000;	//
	D_1532 : real := +0.0;	//
	D_1533 : int  := 00000;	//
	D_1534 : int  := 00000;	//
	D_1535 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_1536 : int  := 00000;	//
	D_1537 : int  := +00000;	//
	D_1538 : word  := B#(000,000);	//
	D_1539 : int  := +00000;	//
	D_1540 : real := 120.000000000000;	// Limit (1)
	D_1541 : real := +0.0;	//
	D_1542 : int  := +00000;	//
	D_1543 : word := 2#0000000000000000;	//
	D_1544 : int := +00000;	//
	D_1545 : real := -120.000000000000;	// Limit (2)
	D_1546 : real := +0.0;	//
	D_1547 : int  := +00000;	//
	D_1548 : word := 2#0000000000000000;	//
	D_1549 : int := +00000;	//
	D_1550 : word := B#(  2,  3);	//  010159 ( 02529 )
	D_1551 : word := 2#0000000000000100;	// ME TEMP CILINDRO 5
	D_1552 : real := +0.0;
	D_1553 : word := 2#0000000000000000;
	D_1554 : int  := +00001;
	D_1555 : int  := +00000;
	D_1556 : int  := +00000;
	D_1557 : word := B#(  0, 0);
	D_1558 : word := B#(000,000);
	D_1559 : word := 2#0000000000000000;
	D_1560 : int  := +00000;
	D_1561 : int  := +00000;
	D_1562 : word := B#(  1,  1);	// State (1)
	D_1563 : word := B#(  0,  1);	//
	D_1564 : word := B#(  5,  8);	//
	D_1565 : int  := +00200;	//
	D_1566 : word := 2#0000000000000000;	//
	D_1567 : word := B#(  0,  0);	//
	D_1568 : word := B#(  1,  1);	// State (2)
	D_1569 : word := B#(  0,  1);	//
	D_1570 : word := B#(  3,  4);	//
	D_1571 : int  := +00000;	//
	D_1572 : word := 2#0000000000000000;	//
	D_1573 : word := B#(  0,  0);	//
	D_1574 : word := B#(  1,  1);	// State (3)
	D_1575 : word := B#(  0,  0);	//
	D_1576 : word := B#(  0,  0);	//
	D_1577 : int  := +00000;	//
	D_1578 : word := 2#0000000000000000;	//
	D_1579 : word := B#(  0,  0);	//
	D_1580 : word := B#(  1,  1);	// State (16)
	D_1581 : word := B#(  0,  1);	//
	D_1582 : word := B#(  15,  12);	//
	D_1583 : int  := +00000;	//
	D_1584 : word := 2#0000000000000000;	//
	D_1585 : word := B#(  0,  0);	//
	D_1586 : real := 0.000000000000;	//
	D_1587 : real := 1300.000000000000;	//
	D_1588 : real := 0.000000000000;	//
	D_1589 : real := 0.000000000000;	//
	D_1590 : real := +0.0;	//
	D_1591 : int  := 00000;	//
	D_1592 : int  := 00000;	//
	D_1593 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_1594 : int  := 00000;	//
	D_1595 : int  := +00000;	//
	D_1596 : word  := B#(000,000);	//
	D_1597 : int  := +00000;	//
	D_1598 : real := 1110.000000000000;	// Limit (1)
	D_1599 : real := +0.0;	//
	D_1600 : int  := +00000;	//
	D_1601 : word := 2#0000000000000000;	//
	D_1602 : int := +00000;	//
	D_1603 : real := 1022.000000000000;	// Limit (2)
	D_1604 : real := +0.0;	//
	D_1605 : int  := +00000;	//
	D_1606 : word := 2#0000000000000000;	//
	D_1607 : int := +00000;	//
	D_1608 : word := B#(  2,  3);	//  010159D ( 02530 )
	D_1609 : word := 2#0000000000000100;	// ME CILINDRO TEMP 5 DESV.
	D_1610 : real := +0.0;
	D_1611 : word := 2#0000000000000000;
	D_1612 : int  := +00001;
	D_1613 : int  := +00000;
	D_1614 : int  := +00000;
	D_1615 : word := B#(  0, 0);
	D_1616 : word := B#(000,000);
	D_1617 : word := 2#0000000000000000;
	D_1618 : int  := +00000;
	D_1619 : int  := +00000;
	D_1620 : word := B#(  1,  1);	// State (1)
	D_1621 : word := B#(  0,  1);	//
	D_1622 : word := B#(  5,  8);	//
	D_1623 : int  := +00200;	//
	D_1624 : word := 2#0000000000000000;	//
	D_1625 : word := B#(  0,  0);	//
	D_1626 : word := B#(  1,  1);	// State (2)
	D_1627 : word := B#(  0,  0);	//
	D_1628 : word := B#(  0,  0);	//
	D_1629 : int  := +00000;	//
	D_1630 : word := 2#0000000000000000;	//
	D_1631 : word := B#(  0,  0);	//
	D_1632 : word := B#(  1,  1);	// State (3)
	D_1633 : word := B#(  0,  1);	//
	D_1634 : word := B#(  6,  1);	//
	D_1635 : int  := +00000;	//
	D_1636 : word := 2#0000000000000000;	//
	D_1637 : word := B#(  0,  0);	//
	D_1638 : word := B#(  1,  1);	// State (16)
	D_1639 : word := B#(  0,  1);	//
	D_1640 : word := B#(  15,  12);	//
	D_1641 : int  := +00000;	//
	D_1642 : word := 2#0000000000000000;	//
	D_1643 : word := B#(  0,  0);	//
	D_1644 : real := -150.000000000000;	//
	D_1645 : real := 150.000000000000;	//
	D_1646 : real := 0.000000000000;	//
	D_1647 : real := 1.500000000000;	//
	D_1648 : real := +0.0;	//
	D_1649 : int  := 00000;	//
	D_1650 : int  := 00000;	//
	D_1651 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_1652 : int  := 00000;	//
	D_1653 : int  := +00000;	//
	D_1654 : word  := B#(000,000);	//
	D_1655 : int  := +00000;	//
	D_1656 : real := 120.000000000000;	// Limit (1)
	D_1657 : real := +0.0;	//
	D_1658 : int  := +00000;	//
	D_1659 : word := 2#0000000000000000;	//
	D_1660 : int := +00000;	//
	D_1661 : real := -120.000000000000;	// Limit (2)
	D_1662 : real := +0.0;	//
	D_1663 : int  := +00000;	//
	D_1664 : word := 2#0000000000000000;	//
	D_1665 : int := +00000;	//
	D_1666 : word := B#(  2,  3);	//  010160 ( 02531 )
	D_1667 : word := 2#0000000000000100;	// ME TEMP CILINDRO 6
	D_1668 : real := +0.0;
	D_1669 : word := 2#0000000000000000;
	D_1670 : int  := +00001;
	D_1671 : int  := +00000;
	D_1672 : int  := +00000;
	D_1673 : word := B#(  0, 0);
	D_1674 : word := B#(000,000);
	D_1675 : word := 2#0000000000000000;
	D_1676 : int  := +00000;
	D_1677 : int  := +00000;
	D_1678 : word := B#(  1,  1);	// State (1)
	D_1679 : word := B#(  0,  1);	//
	D_1680 : word := B#(  5,  8);	//
	D_1681 : int  := +00200;	//
	D_1682 : word := 2#0000000000000000;	//
	D_1683 : word := B#(  0,  0);	//
	D_1684 : word := B#(  1,  1);	// State (2)
	D_1685 : word := B#(  0,  1);	//
	D_1686 : word := B#(  3,  4);	//
	D_1687 : int  := +00000;	//
	D_1688 : word := 2#0000000000000000;	//
	D_1689 : word := B#(  0,  0);	//
	D_1690 : word := B#(  1,  1);	// State (3)
	D_1691 : word := B#(  0,  0);	//
	D_1692 : word := B#(  0,  0);	//
	D_1693 : int  := +00000;	//
	D_1694 : word := 2#0000000000000000;	//
	D_1695 : word := B#(  0,  0);	//
	D_1696 : word := B#(  1,  1);	// State (16)
	D_1697 : word := B#(  0,  1);	//
	D_1698 : word := B#(  15,  12);	//
	D_1699 : int  := +00000;	//
	D_1700 : word := 2#0000000000000000;	//
	D_1701 : word := B#(  0,  0);	//
	D_1702 : real := 0.000000000000;	//
	D_1703 : real := 1300.000000000000;	//
	D_1704 : real := 0.000000000000;	//
	D_1705 : real := 0.000000000000;	//
	D_1706 : real := +0.0;	//
	D_1707 : int  := 00000;	//
	D_1708 : int  := 00000;	//
	D_1709 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_1710 : int  := 00000;	//
	D_1711 : int  := +00000;	//
	D_1712 : word  := B#(000,000);	//
	D_1713 : int  := +00000;	//
	D_1714 : real := 1110.000000000000;	// Limit (1)
	D_1715 : real := +0.0;	//
	D_1716 : int  := +00000;	//
	D_1717 : word := 2#0000000000000000;	//
	D_1718 : int := +00000;	//
	D_1719 : real := 1022.000000000000;	// Limit (2)
	D_1720 : real := +0.0;	//
	D_1721 : int  := +00000;	//
	D_1722 : word := 2#0000000000000000;	//
	D_1723 : int := +00000;	//
	D_1724 : word := B#(  2,  3);	//  010160D ( 02532 )
	D_1725 : word := 2#0000000000000100;	// ME CILINDRO TEMP 6 DESV.
	D_1726 : real := +0.0;
	D_1727 : word := 2#0000000000000000;
	D_1728 : int  := +00001;
	D_1729 : int  := +00000;
	D_1730 : int  := +00000;
	D_1731 : word := B#(  0, 0);
	D_1732 : word := B#(000,000);
	D_1733 : word := 2#0000000000000000;
	D_1734 : int  := +00000;
	D_1735 : int  := +00000;
	D_1736 : word := B#(  1,  1);	// State (1)
	D_1737 : word := B#(  0,  1);	//
	D_1738 : word := B#(  5,  8);	//
	D_1739 : int  := +00200;	//
	D_1740 : word := 2#0000000000000000;	//
	D_1741 : word := B#(  0,  0);	//
	D_1742 : word := B#(  1,  1);	// State (2)
	D_1743 : word := B#(  0,  0);	//
	D_1744 : word := B#(  0,  0);	//
	D_1745 : int  := +00000;	//
	D_1746 : word := 2#0000000000000000;	//
	D_1747 : word := B#(  0,  0);	//
	D_1748 : word := B#(  1,  1);	// State (3)
	D_1749 : word := B#(  0,  1);	//
	D_1750 : word := B#(  6,  1);	//
	D_1751 : int  := +00000;	//
	D_1752 : word := 2#0000000000000000;	//
	D_1753 : word := B#(  0,  0);	//
	D_1754 : word := B#(  1,  1);	// State (16)
	D_1755 : word := B#(  0,  1);	//
	D_1756 : word := B#(  15,  12);	//
	D_1757 : int  := +00000;	//
	D_1758 : word := 2#0000000000000000;	//
	D_1759 : word := B#(  0,  0);	//
	D_1760 : real := -150.000000000000;	//
	D_1761 : real := 150.000000000000;	//
	D_1762 : real := 0.000000000000;	//
	D_1763 : real := 1.500000000000;	//
	D_1764 : real := +0.0;	//
	D_1765 : int  := 00000;	//
	D_1766 : int  := 00000;	//
	D_1767 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_1768 : int  := 00000;	//
	D_1769 : int  := +00000;	//
	D_1770 : word  := B#(000,000);	//
	D_1771 : int  := +00000;	//
	D_1772 : real := 120.000000000000;	// Limit (1)
	D_1773 : real := +0.0;	//
	D_1774 : int  := +00000;	//
	D_1775 : word := 2#0000000000000000;	//
	D_1776 : int := +00000;	//
	D_1777 : real := -120.000000000000;	// Limit (2)
	D_1778 : real := +0.0;	//
	D_1779 : int  := +00000;	//
	D_1780 : word := 2#0000000000000000;	//
	D_1781 : int := +00000;	//
	D_1782 : word := B#(  2,  3);	//  010161 ( 02533 )
	D_1783 : word := 2#0000000000000100;	// ME TEMP CILINDRO 7
	D_1784 : real := +0.0;
	D_1785 : word := 2#0000000000000000;
	D_1786 : int  := +00001;
	D_1787 : int  := +00000;
	D_1788 : int  := +00000;
	D_1789 : word := B#(  0, 0);
	D_1790 : word := B#(000,000);
	D_1791 : word := 2#0000000000000000;
	D_1792 : int  := +00000;
	D_1793 : int  := +00000;
	D_1794 : word := B#(  1,  1);	// State (1)
	D_1795 : word := B#(  0,  1);	//
	D_1796 : word := B#(  5,  8);	//
	D_1797 : int  := +00200;	//
	D_1798 : word := 2#0000000000000000;	//
	D_1799 : word := B#(  0,  0);	//
	D_1800 : word := B#(  1,  1);	// State (2)
	D_1801 : word := B#(  0,  1);	//
	D_1802 : word := B#(  3,  4);	//
	D_1803 : int  := +00000;	//
	D_1804 : word := 2#0000000000000000;	//
	D_1805 : word := B#(  0,  0);	//
	D_1806 : word := B#(  1,  1);	// State (3)
	D_1807 : word := B#(  0,  0);	//
	D_1808 : word := B#(  0,  0);	//
	D_1809 : int  := +00000;	//
	D_1810 : word := 2#0000000000000000;	//
	D_1811 : word := B#(  0,  0);	//
	D_1812 : word := B#(  1,  1);	// State (16)
	D_1813 : word := B#(  0,  1);	//
	D_1814 : word := B#(  15,  12);	//
	D_1815 : int  := +00000;	//
	D_1816 : word := 2#0000000000000000;	//
	D_1817 : word := B#(  0,  0);	//
	D_1818 : real := 0.000000000000;	//
	D_1819 : real := 1300.000000000000;	//
	D_1820 : real := 0.000000000000;	//
	D_1821 : real := 0.000000000000;	//
	D_1822 : real := +0.0;	//
	D_1823 : int  := 00000;	//
	D_1824 : int  := 00000;	//
	D_1825 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_1826 : int  := 00000;	//
	D_1827 : int  := +00000;	//
	D_1828 : word  := B#(000,000);	//
	D_1829 : int  := +00000;	//
	D_1830 : real := 1110.000000000000;	// Limit (1)
	D_1831 : real := +0.0;	//
	D_1832 : int  := +00000;	//
	D_1833 : word := 2#0000000000000000;	//
	D_1834 : int := +00000;	//
	D_1835 : real := 1022.000000000000;	// Limit (2)
	D_1836 : real := +0.0;	//
	D_1837 : int  := +00000;	//
	D_1838 : word := 2#0000000000000000;	//
	D_1839 : int := +00000;	//
	D_1840 : word := B#(  2,  3);	//  010161D ( 02534 )
	D_1841 : word := 2#0000000000000100;	// ME CILINDRO TEMP 7 DESV.
	D_1842 : real := +0.0;
	D_1843 : word := 2#0000000000000000;
	D_1844 : int  := +00001;
	D_1845 : int  := +00000;
	D_1846 : int  := +00000;
	D_1847 : word := B#(  0, 0);
	D_1848 : word := B#(000,000);
	D_1849 : word := 2#0000000000000000;
	D_1850 : int  := +00000;
	D_1851 : int  := +00000;
	D_1852 : word := B#(  1,  1);	// State (1)
	D_1853 : word := B#(  0,  1);	//
	D_1854 : word := B#(  5,  8);	//
	D_1855 : int  := +00200;	//
	D_1856 : word := 2#0000000000000000;	//
	D_1857 : word := B#(  0,  0);	//
	D_1858 : word := B#(  1,  1);	// State (2)
	D_1859 : word := B#(  0,  0);	//
	D_1860 : word := B#(  0,  0);	//
	D_1861 : int  := +00000;	//
	D_1862 : word := 2#0000000000000000;	//
	D_1863 : word := B#(  0,  0);	//
	D_1864 : word := B#(  1,  1);	// State (3)
	D_1865 : word := B#(  0,  1);	//
	D_1866 : word := B#(  6,  1);	//
	D_1867 : int  := +00000;	//
	D_1868 : word := 2#0000000000000000;	//
	D_1869 : word := B#(  0,  0);	//
	D_1870 : word := B#(  1,  1);	// State (16)
	D_1871 : word := B#(  0,  1);	//
	D_1872 : word := B#(  15,  12);	//
	D_1873 : int  := +00000;	//
	D_1874 : word := 2#0000000000000000;	//
	D_1875 : word := B#(  0,  0);	//
	D_1876 : real := -150.000000000000;	//
	D_1877 : real := 150.000000000000;	//
	D_1878 : real := 0.000000000000;	//
	D_1879 : real := 1.500000000000;	//
	D_1880 : real := +0.0;	//
	D_1881 : int  := 00000;	//
	D_1882 : int  := 00000;	//
	D_1883 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_1884 : int  := 00000;	//
	D_1885 : int  := +00000;	//
	D_1886 : word  := B#(000,000);	//
	D_1887 : int  := +00000;	//
	D_1888 : real := 120.000000000000;	// Limit (1)
	D_1889 : real := +0.0;	//
	D_1890 : int  := +00000;	//
	D_1891 : word := 2#0000000000000000;	//
	D_1892 : int := +00000;	//
	D_1893 : real := -120.000000000000;	// Limit (2)
	D_1894 : real := +0.0;	//
	D_1895 : int  := +00000;	//
	D_1896 : word := 2#0000000000000000;	//
	D_1897 : int := +00000;	//
	D_1898 : word := B#(  2,  3);	//  010162 ( 02535 )
	D_1899 : word := 2#0000000000000100;	// ME TEMP CILINDRO 8
	D_1900 : real := +0.0;
	D_1901 : word := 2#0000000000000000;
	D_1902 : int  := +00001;
	D_1903 : int  := +00000;
	D_1904 : int  := +00000;
	D_1905 : word := B#(  0, 0);
	D_1906 : word := B#(000,000);
	D_1907 : word := 2#0000000000000000;
	D_1908 : int  := +00000;
	D_1909 : int  := +00000;
	D_1910 : word := B#(  1,  1);	// State (1)
	D_1911 : word := B#(  0,  1);	//
	D_1912 : word := B#(  5,  8);	//
	D_1913 : int  := +00200;	//
	D_1914 : word := 2#0000000000000000;	//
	D_1915 : word := B#(  0,  0);	//
	D_1916 : word := B#(  1,  1);	// State (2)
	D_1917 : word := B#(  0,  1);	//
	D_1918 : word := B#(  3,  4);	//
	D_1919 : int  := +00000;	//
	D_1920 : word := 2#0000000000000000;	//
	D_1921 : word := B#(  0,  0);	//
	D_1922 : word := B#(  1,  1);	// State (3)
	D_1923 : word := B#(  0,  0);	//
	D_1924 : word := B#(  0,  0);	//
	D_1925 : int  := +00000;	//
	D_1926 : word := 2#0000000000000000;	//
	D_1927 : word := B#(  0,  0);	//
	D_1928 : word := B#(  1,  1);	// State (16)
	D_1929 : word := B#(  0,  1);	//
	D_1930 : word := B#(  15,  12);	//
	D_1931 : int  := +00000;	//
	D_1932 : word := 2#0000000000000000;	//
	D_1933 : word := B#(  0,  0);	//
	D_1934 : real := 0.000000000000;	//
	D_1935 : real := 1300.000000000000;	//
	D_1936 : real := 0.000000000000;	//
	D_1937 : real := 0.000000000000;	//
	D_1938 : real := +0.0;	//
	D_1939 : int  := 00000;	//
	D_1940 : int  := 00000;	//
	D_1941 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_1942 : int  := 00000;	//
	D_1943 : int  := +00000;	//
	D_1944 : word  := B#(000,000);	//
	D_1945 : int  := +00000;	//
	D_1946 : real := 1110.000000000000;	// Limit (1)
	D_1947 : real := +0.0;	//
	D_1948 : int  := +00000;	//
	D_1949 : word := 2#0000000000000000;	//
	D_1950 : int := +00000;	//
	D_1951 : real := 1022.000000000000;	// Limit (2)
	D_1952 : real := +0.0;	//
	D_1953 : int  := +00000;	//
	D_1954 : word := 2#0000000000000000;	//
	D_1955 : int := +00000;	//
	D_1956 : word := B#(  2,  3);	//  010162D ( 02536 )
	D_1957 : word := 2#0000000000000100;	// ME  CILINDRO TEMP 8 DESV.
	D_1958 : real := +0.0;
	D_1959 : word := 2#0000000000000000;
	D_1960 : int  := +00001;
	D_1961 : int  := +00000;
	D_1962 : int  := +00000;
	D_1963 : word := B#(  0, 0);
	D_1964 : word := B#(000,000);
	D_1965 : word := 2#0000000000000000;
	D_1966 : int  := +00000;
	D_1967 : int  := +00000;
	D_1968 : word := B#(  1,  1);	// State (1)
	D_1969 : word := B#(  0,  1);	//
	D_1970 : word := B#(  5,  8);	//
	D_1971 : int  := +00200;	//
	D_1972 : word := 2#0000000000000000;	//
	D_1973 : word := B#(  0,  0);	//
	D_1974 : word := B#(  1,  1);	// State (2)
	D_1975 : word := B#(  0,  0);	//
	D_1976 : word := B#(  0,  0);	//
	D_1977 : int  := +00000;	//
	D_1978 : word := 2#0000000000000000;	//
	D_1979 : word := B#(  0,  0);	//
	D_1980 : word := B#(  1,  1);	// State (3)
	D_1981 : word := B#(  0,  1);	//
	D_1982 : word := B#(  6,  1);	//
	D_1983 : int  := +00000;	//
	D_1984 : word := 2#0000000000000000;	//
	D_1985 : word := B#(  0,  0);	//
	D_1986 : word := B#(  1,  1);	// State (16)
	D_1987 : word := B#(  0,  1);	//
	D_1988 : word := B#(  15,  12);	//
	D_1989 : int  := +00000;	//
	D_1990 : word := 2#0000000000000000;	//
	D_1991 : word := B#(  0,  0);	//
	D_1992 : real := -150.000000000000;	//
	D_1993 : real := 150.000000000000;	//
	D_1994 : real := 0.000000000000;	//
	D_1995 : real := 1.500000000000;	//
	D_1996 : real := +0.0;	//
	D_1997 : int  := 00000;	//
	D_1998 : int  := 00000;	//
	D_1999 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_2000 : int  := 00000;	//
	D_2001 : int  := +00000;	//
	D_2002 : word  := B#(000,000);	//
	D_2003 : int  := +00000;	//
	D_2004 : real := 120.000000000000;	// Limit (1)
	D_2005 : real := +0.0;	//
	D_2006 : int  := +00000;	//
	D_2007 : word := 2#0000000000000000;	//
	D_2008 : int := +00000;	//
	D_2009 : real := -120.000000000000;	// Limit (2)
	D_2010 : real := +0.0;	//
	D_2011 : int  := +00000;	//
	D_2012 : word := 2#0000000000000000;	//
	D_2013 : int := +00000;	//
	D_2014 : word := B#(  2,  3);	//  010163 ( 02537 )
	D_2015 : word := 2#0000000000000100;	// ME TEMP CILINDRO 9
	D_2016 : real := +0.0;
	D_2017 : word := 2#0000000000000000;
	D_2018 : int  := +00001;
	D_2019 : int  := +00000;
	D_2020 : int  := +00000;
	D_2021 : word := B#(  0, 0);
	D_2022 : word := B#(000,000);
	D_2023 : word := 2#0000000000000000;
	D_2024 : int  := +00000;
	D_2025 : int  := +00000;
	D_2026 : word := B#(  1,  1);	// State (1)
	D_2027 : word := B#(  0,  1);	//
	D_2028 : word := B#(  5,  8);	//
	D_2029 : int  := +00200;	//
	D_2030 : word := 2#0000000000000000;	//
	D_2031 : word := B#(  0,  0);	//
	D_2032 : word := B#(  1,  1);	// State (2)
	D_2033 : word := B#(  0,  1);	//
	D_2034 : word := B#(  3,  4);	//
	D_2035 : int  := +00000;	//
	D_2036 : word := 2#0000000000000000;	//
	D_2037 : word := B#(  0,  0);	//
	D_2038 : word := B#(  1,  1);	// State (3)
	D_2039 : word := B#(  0,  0);	//
	D_2040 : word := B#(  0,  0);	//
	D_2041 : int  := +00000;	//
	D_2042 : word := 2#0000000000000000;	//
	D_2043 : word := B#(  0,  0);	//
	D_2044 : word := B#(  1,  1);	// State (16)
	D_2045 : word := B#(  0,  1);	//
	D_2046 : word := B#(  15,  12);	//
	D_2047 : int  := +00000;	//
	D_2048 : word := 2#0000000000000000;	//
	D_2049 : word := B#(  0,  0);	//
	D_2050 : real := 0.000000000000;	//
	D_2051 : real := 1300.000000000000;	//
	D_2052 : real := 0.000000000000;	//
	D_2053 : real := 0.000000000000;	//
	D_2054 : real := +0.0;	//
	D_2055 : int  := 00000;	//
	D_2056 : int  := 00000;	//
	D_2057 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_2058 : int  := 00000;	//
	D_2059 : int  := +00000;	//
	D_2060 : word  := B#(000,000);	//
	D_2061 : int  := +00000;	//
	D_2062 : real := 1110.000000000000;	// Limit (1)
	D_2063 : real := +0.0;	//
	D_2064 : int  := +00000;	//
	D_2065 : word := 2#0000000000000000;	//
	D_2066 : int := +00000;	//
	D_2067 : real := 1022.000000000000;	// Limit (2)
	D_2068 : real := +0.0;	//
	D_2069 : int  := +00000;	//
	D_2070 : word := 2#0000000000000000;	//
	D_2071 : int := +00000;	//
	D_2072 : word := B#(  2,  3);	//  010163D ( 02538 )
	D_2073 : word := 2#0000000000000100;	// ME CILINDRO TEMP 9 DESV.
	D_2074 : real := +0.0;
	D_2075 : word := 2#0000000000000000;
	D_2076 : int  := +00001;
	D_2077 : int  := +00000;
	D_2078 : int  := +00000;
	D_2079 : word := B#(  0, 0);
	D_2080 : word := B#(000,000);
	D_2081 : word := 2#0000000000000000;
	D_2082 : int  := +00000;
	D_2083 : int  := +00000;
	D_2084 : word := B#(  1,  1);	// State (1)
	D_2085 : word := B#(  0,  1);	//
	D_2086 : word := B#(  5,  8);	//
	D_2087 : int  := +00200;	//
	D_2088 : word := 2#0000000000000000;	//
	D_2089 : word := B#(  0,  0);	//
	D_2090 : word := B#(  1,  1);	// State (2)
	D_2091 : word := B#(  0,  0);	//
	D_2092 : word := B#(  0,  0);	//
	D_2093 : int  := +00000;	//
	D_2094 : word := 2#0000000000000000;	//
	D_2095 : word := B#(  0,  0);	//
	D_2096 : word := B#(  1,  1);	// State (3)
	D_2097 : word := B#(  0,  1);	//
	D_2098 : word := B#(  6,  1);	//
	D_2099 : int  := +00000;	//
	D_2100 : word := 2#0000000000000000;	//
	D_2101 : word := B#(  0,  0);	//
	D_2102 : word := B#(  1,  1);	// State (16)
	D_2103 : word := B#(  0,  1);	//
	D_2104 : word := B#(  15,  12);	//
	D_2105 : int  := +00000;	//
	D_2106 : word := 2#0000000000000000;	//
	D_2107 : word := B#(  0,  0);	//
	D_2108 : real := -150.000000000000;	//
	D_2109 : real := 150.000000000000;	//
	D_2110 : real := 0.000000000000;	//
	D_2111 : real := 1.500000000000;	//
	D_2112 : real := +0.0;	//
	D_2113 : int  := 00000;	//
	D_2114 : int  := 00000;	//
	D_2115 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_2116 : int  := 00000;	//
	D_2117 : int  := +00000;	//
	D_2118 : word  := B#(000,000);	//
	D_2119 : int  := +00000;	//
	D_2120 : real := 120.000000000000;	// Limit (1)
	D_2121 : real := +0.0;	//
	D_2122 : int  := +00000;	//
	D_2123 : word := 2#0000000000000000;	//
	D_2124 : int := +00000;	//
	D_2125 : real := -120.000000000000;	// Limit (2)
	D_2126 : real := +0.0;	//
	D_2127 : int  := +00000;	//
	D_2128 : word := 2#0000000000000000;	//
	D_2129 : int := +00000;	//
	D_2130 : word := B#(  2,  3);	//  010164 ( 02539 )
	D_2131 : word := 2#0000000000000100;	// ME TEMP CILINDRO 10
	D_2132 : real := +0.0;
	D_2133 : word := 2#0000000000000000;
	D_2134 : int  := +00001;
	D_2135 : int  := +00000;
	D_2136 : int  := +00000;
	D_2137 : word := B#(  0, 0);
	D_2138 : word := B#(000,000);
	D_2139 : word := 2#0000000000000000;
	D_2140 : int  := +00000;
	D_2141 : int  := +00000;
	D_2142 : word := B#(  1,  1);	// State (1)
	D_2143 : word := B#(  0,  1);	//
	D_2144 : word := B#(  5,  8);	//
	D_2145 : int  := +00200;	//
	D_2146 : word := 2#0000000000000000;	//
	D_2147 : word := B#(  0,  0);	//
	D_2148 : word := B#(  1,  1);	// State (2)
	D_2149 : word := B#(  0,  1);	//
	D_2150 : word := B#(  3,  4);	//
	D_2151 : int  := +00000;	//
	D_2152 : word := 2#0000000000000000;	//
	D_2153 : word := B#(  0,  0);	//
	D_2154 : word := B#(  1,  1);	// State (3)
	D_2155 : word := B#(  0,  0);	//
	D_2156 : word := B#(  0,  0);	//
	D_2157 : int  := +00000;	//
	D_2158 : word := 2#0000000000000000;	//
	D_2159 : word := B#(  0,  0);	//
	D_2160 : word := B#(  1,  1);	// State (16)
	D_2161 : word := B#(  0,  1);	//
	D_2162 : word := B#(  15,  12);	//
	D_2163 : int  := +00000;	//
	D_2164 : word := 2#0000000000000000;	//
	D_2165 : word := B#(  0,  0);	//
	D_2166 : real := 0.000000000000;	//
	D_2167 : real := 1300.000000000000;	//
	D_2168 : real := 0.000000000000;	//
	D_2169 : real := 0.000000000000;	//
	D_2170 : real := +0.0;	//
	D_2171 : int  := 00000;	//
	D_2172 : int  := 00000;	//
	D_2173 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_2174 : int  := 00000;	//
	D_2175 : int  := +00000;	//
	D_2176 : word  := B#(000,000);	//
	D_2177 : int  := +00000;	//
	D_2178 : real := 1110.000000000000;	// Limit (1)
	D_2179 : real := +0.0;	//
	D_2180 : int  := +00000;	//
	D_2181 : word := 2#0000000000000000;	//
	D_2182 : int := +00000;	//
	D_2183 : real := 1022.000000000000;	// Limit (2)
	D_2184 : real := +0.0;	//
	D_2185 : int  := +00000;	//
	D_2186 : word := 2#0000000000000000;	//
	D_2187 : int := +00000;	//
	D_2188 : word := B#(  2,  3);	//  010164D ( 02540 )
	D_2189 : word := 2#0000000000000100;	// ME CILINDRO TEMP 10 DESV.
	D_2190 : real := +0.0;
	D_2191 : word := 2#0000000000000000;
	D_2192 : int  := +00001;
	D_2193 : int  := +00000;
	D_2194 : int  := +00000;
	D_2195 : word := B#(  0, 0);
	D_2196 : word := B#(000,000);
	D_2197 : word := 2#0000000000000000;
	D_2198 : int  := +00000;
	D_2199 : int  := +00000;
	D_2200 : word := B#(  1,  1);	// State (1)
	D_2201 : word := B#(  0,  1);	//
	D_2202 : word := B#(  5,  8);	//
	D_2203 : int  := +00200;	//
	D_2204 : word := 2#0000000000000000;	//
	D_2205 : word := B#(  0,  0);	//
	D_2206 : word := B#(  1,  1);	// State (2)
	D_2207 : word := B#(  0,  0);	//
	D_2208 : word := B#(  0,  0);	//
	D_2209 : int  := +00000;	//
	D_2210 : word := 2#0000000000000000;	//
	D_2211 : word := B#(  0,  0);	//
	D_2212 : word := B#(  1,  1);	// State (3)
	D_2213 : word := B#(  0,  1);	//
	D_2214 : word := B#(  6,  1);	//
	D_2215 : int  := +00000;	//
	D_2216 : word := 2#0000000000000000;	//
	D_2217 : word := B#(  0,  0);	//
	D_2218 : word := B#(  1,  1);	// State (16)
	D_2219 : word := B#(  0,  1);	//
	D_2220 : word := B#(  15,  12);	//
	D_2221 : int  := +00000;	//
	D_2222 : word := 2#0000000000000000;	//
	D_2223 : word := B#(  0,  0);	//
	D_2224 : real := -150.000000000000;	//
	D_2225 : real := 150.000000000000;	//
	D_2226 : real := 0.000000000000;	//
	D_2227 : real := 1.500000000000;	//
	D_2228 : real := +0.0;	//
	D_2229 : int  := 00000;	//
	D_2230 : int  := 00000;	//
	D_2231 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_2232 : int  := 00000;	//
	D_2233 : int  := +00000;	//
	D_2234 : word  := B#(000,000);	//
	D_2235 : int  := +00000;	//
	D_2236 : real := 120.000000000000;	// Limit (1)
	D_2237 : real := +0.0;	//
	D_2238 : int  := +00000;	//
	D_2239 : word := 2#0000000000000000;	//
	D_2240 : int := +00000;	//
	D_2241 : real := -120.000000000000;	// Limit (2)
	D_2242 : real := +0.0;	//
	D_2243 : int  := +00000;	//
	D_2244 : word := 2#0000000000000000;	//
	D_2245 : int := +00000;	//
	D_2246 : word := B#(  2,  3);	//  010165 ( 02541 )
	D_2247 : word := 2#0000000000000100;	// ME TEMP CILINDRO 11
	D_2248 : real := +0.0;
	D_2249 : word := 2#0000000000000000;
	D_2250 : int  := +00001;
	D_2251 : int  := +00000;
	D_2252 : int  := +00000;
	D_2253 : word := B#(  0, 0);
	D_2254 : word := B#(000,000);
	D_2255 : word := 2#0000000000000000;
	D_2256 : int  := +00000;
	D_2257 : int  := +00000;
	D_2258 : word := B#(  1,  1);	// State (1)
	D_2259 : word := B#(  0,  1);	//
	D_2260 : word := B#(  5,  8);	//
	D_2261 : int  := +00200;	//
	D_2262 : word := 2#0000000000000000;	//
	D_2263 : word := B#(  0,  0);	//
	D_2264 : word := B#(  1,  1);	// State (2)
	D_2265 : word := B#(  0,  1);	//
	D_2266 : word := B#(  3,  4);	//
	D_2267 : int  := +00000;	//
	D_2268 : word := 2#0000000000000000;	//
	D_2269 : word := B#(  0,  0);	//
	D_2270 : word := B#(  1,  1);	// State (3)
	D_2271 : word := B#(  0,  0);	//
	D_2272 : word := B#(  0,  0);	//
	D_2273 : int  := +00000;	//
	D_2274 : word := 2#0000000000000000;	//
	D_2275 : word := B#(  0,  0);	//
	D_2276 : word := B#(  1,  1);	// State (16)
	D_2277 : word := B#(  0,  1);	//
	D_2278 : word := B#(  15,  12);	//
	D_2279 : int  := +00000;	//
	D_2280 : word := 2#0000000000000000;	//
	D_2281 : word := B#(  0,  0);	//
	D_2282 : real := 0.000000000000;	//
	D_2283 : real := 1300.000000000000;	//
	D_2284 : real := 0.000000000000;	//
	D_2285 : real := 0.000000000000;	//
	D_2286 : real := +0.0;	//
	D_2287 : int  := 00000;	//
	D_2288 : int  := 00000;	//
	D_2289 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_2290 : int  := 00000;	//
	D_2291 : int  := +00000;	//
	D_2292 : word  := B#(000,000);	//
	D_2293 : int  := +00000;	//
	D_2294 : real := 1110.000000000000;	// Limit (1)
	D_2295 : real := +0.0;	//
	D_2296 : int  := +00000;	//
	D_2297 : word := 2#0000000000000000;	//
	D_2298 : int := +00000;	//
	D_2299 : real := 1022.000000000000;	// Limit (2)
	D_2300 : real := +0.0;	//
	D_2301 : int  := +00000;	//
	D_2302 : word := 2#0000000000000000;	//
	D_2303 : int := +00000;	//
	D_2304 : word := B#(  2,  3);	//  010165D ( 02542 )
	D_2305 : word := 2#0000000000000100;	// ME CILINDRO TEMP 11 DESV.
	D_2306 : real := +0.0;
	D_2307 : word := 2#0000000000000000;
	D_2308 : int  := +00001;
	D_2309 : int  := +00000;
	D_2310 : int  := +00000;
	D_2311 : word := B#(  0, 0);
	D_2312 : word := B#(000,000);
	D_2313 : word := 2#0000000000000000;
	D_2314 : int  := +00000;
	D_2315 : int  := +00000;
	D_2316 : word := B#(  1,  1);	// State (1)
	D_2317 : word := B#(  0,  1);	//
	D_2318 : word := B#(  5,  8);	//
	D_2319 : int  := +00200;	//
	D_2320 : word := 2#0000000000000000;	//
	D_2321 : word := B#(  0,  0);	//
	D_2322 : word := B#(  1,  1);	// State (2)
	D_2323 : word := B#(  0,  0);	//
	D_2324 : word := B#(  0,  0);	//
	D_2325 : int  := +00000;	//
	D_2326 : word := 2#0000000000000000;	//
	D_2327 : word := B#(  0,  0);	//
	D_2328 : word := B#(  1,  1);	// State (3)
	D_2329 : word := B#(  0,  1);	//
	D_2330 : word := B#(  6,  1);	//
	D_2331 : int  := +00000;	//
	D_2332 : word := 2#0000000000000000;	//
	D_2333 : word := B#(  0,  0);	//
	D_2334 : word := B#(  1,  1);	// State (16)
	D_2335 : word := B#(  0,  1);	//
	D_2336 : word := B#(  15,  12);	//
	D_2337 : int  := +00000;	//
	D_2338 : word := 2#0000000000000000;	//
	D_2339 : word := B#(  0,  0);	//
	D_2340 : real := -150.000000000000;	//
	D_2341 : real := 150.000000000000;	//
	D_2342 : real := 0.000000000000;	//
	D_2343 : real := 1.500000000000;	//
	D_2344 : real := +0.0;	//
	D_2345 : int  := 00000;	//
	D_2346 : int  := 00000;	//
	D_2347 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_2348 : int  := 00000;	//
	D_2349 : int  := +00000;	//
	D_2350 : word  := B#(000,000);	//
	D_2351 : int  := +00000;	//
	D_2352 : real := 120.000000000000;	// Limit (1)
	D_2353 : real := +0.0;	//
	D_2354 : int  := +00000;	//
	D_2355 : word := 2#0000000000000000;	//
	D_2356 : int := +00000;	//
	D_2357 : real := -120.000000000000;	// Limit (2)
	D_2358 : real := +0.0;	//
	D_2359 : int  := +00000;	//
	D_2360 : word := 2#0000000000000000;	//
	D_2361 : int := +00000;	//
	D_2362 : word := B#(  2,  3);	//  010166 ( 02543 )
	D_2363 : word := 2#0000000000000100;	// ME TEMP CILINDRO 12
	D_2364 : real := +0.0;
	D_2365 : word := 2#0000000000000000;
	D_2366 : int  := +00001;
	D_2367 : int  := +00000;
	D_2368 : int  := +00000;
	D_2369 : word := B#(  0, 0);
	D_2370 : word := B#(000,000);
	D_2371 : word := 2#0000000000000000;
	D_2372 : int  := +00000;
	D_2373 : int  := +00000;
	D_2374 : word := B#(  1,  1);	// State (1)
	D_2375 : word := B#(  0,  1);	//
	D_2376 : word := B#(  5,  8);	//
	D_2377 : int  := +00200;	//
	D_2378 : word := 2#0000000000000000;	//
	D_2379 : word := B#(  0,  0);	//
	D_2380 : word := B#(  1,  1);	// State (2)
	D_2381 : word := B#(  0,  1);	//
	D_2382 : word := B#(  3,  4);	//
	D_2383 : int  := +00000;	//
	D_2384 : word := 2#0000000000000000;	//
	D_2385 : word := B#(  0,  0);	//
	D_2386 : word := B#(  1,  1);	// State (3)
	D_2387 : word := B#(  0,  0);	//
	D_2388 : word := B#(  0,  0);	//
	D_2389 : int  := +00000;	//
	D_2390 : word := 2#0000000000000000;	//
	D_2391 : word := B#(  0,  0);	//
	D_2392 : word := B#(  1,  1);	// State (16)
	D_2393 : word := B#(  0,  1);	//
	D_2394 : word := B#(  15,  12);	//
	D_2395 : int  := +00000;	//
	D_2396 : word := 2#0000000000000000;	//
	D_2397 : word := B#(  0,  0);	//
	D_2398 : real := 0.000000000000;	//
	D_2399 : real := 1300.000000000000;	//
	D_2400 : real := 0.000000000000;	//
	D_2401 : real := 0.000000000000;	//
	D_2402 : real := +0.0;	//
	D_2403 : int  := 00000;	//
	D_2404 : int  := 00000;	//
	D_2405 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_2406 : int  := 00000;	//
	D_2407 : int  := +00000;	//
	D_2408 : word  := B#(000,000);	//
	D_2409 : int  := +00000;	//
	D_2410 : real := 1110.000000000000;	// Limit (1)
	D_2411 : real := +0.0;	//
	D_2412 : int  := +00000;	//
	D_2413 : word := 2#0000000000000000;	//
	D_2414 : int := +00000;	//
	D_2415 : real := 1022.000000000000;	// Limit (2)
	D_2416 : real := +0.0;	//
	D_2417 : int  := +00000;	//
	D_2418 : word := 2#0000000000000000;	//
	D_2419 : int := +00000;	//
	D_2420 : word := B#(  2,  3);	//  010166D ( 02544 )
	D_2421 : word := 2#0000000000000100;	// ME CILINDRO TEMP 12 DESV.
	D_2422 : real := +0.0;
	D_2423 : word := 2#0000000000000000;
	D_2424 : int  := +00001;
	D_2425 : int  := +00000;
	D_2426 : int  := +00000;
	D_2427 : word := B#(  0, 0);
	D_2428 : word := B#(000,000);
	D_2429 : word := 2#0000000000000000;
	D_2430 : int  := +00000;
	D_2431 : int  := +00000;
	D_2432 : word := B#(  1,  1);	// State (1)
	D_2433 : word := B#(  0,  1);	//
	D_2434 : word := B#(  5,  8);	//
	D_2435 : int  := +00200;	//
	D_2436 : word := 2#0000000000000000;	//
	D_2437 : word := B#(  0,  0);	//
	D_2438 : word := B#(  1,  1);	// State (2)
	D_2439 : word := B#(  0,  0);	//
	D_2440 : word := B#(  0,  0);	//
	D_2441 : int  := +00000;	//
	D_2442 : word := 2#0000000000000000;	//
	D_2443 : word := B#(  0,  0);	//
	D_2444 : word := B#(  1,  1);	// State (3)
	D_2445 : word := B#(  0,  1);	//
	D_2446 : word := B#(  6,  1);	//
	D_2447 : int  := +00000;	//
	D_2448 : word := 2#0000000000000000;	//
	D_2449 : word := B#(  0,  0);	//
	D_2450 : word := B#(  1,  1);	// State (16)
	D_2451 : word := B#(  0,  1);	//
	D_2452 : word := B#(  15,  12);	//
	D_2453 : int  := +00000;	//
	D_2454 : word := 2#0000000000000000;	//
	D_2455 : word := B#(  0,  0);	//
	D_2456 : real := -150.000000000000;	//
	D_2457 : real := 150.000000000000;	//
	D_2458 : real := 0.000000000000;	//
	D_2459 : real := 1.500000000000;	//
	D_2460 : real := +0.0;	//
	D_2461 : int  := 00000;	//
	D_2462 : int  := 00000;	//
	D_2463 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_2464 : int  := 00000;	//
	D_2465 : int  := +00000;	//
	D_2466 : word  := B#(000,000);	//
	D_2467 : int  := +00000;	//
	D_2468 : real := 120.000000000000;	// Limit (1)
	D_2469 : real := +0.0;	//
	D_2470 : int  := +00000;	//
	D_2471 : word := 2#0000000000000000;	//
	D_2472 : int := +00000;	//
	D_2473 : real := -120.000000000000;	// Limit (2)
	D_2474 : real := +0.0;	//
	D_2475 : int  := +00000;	//
	D_2476 : word := 2#0000000000000000;	//
	D_2477 : int := +00000;	//
	D_2478 : word := B#(  2,  3);	//  010167 ( 02545 )
	D_2479 : word := 2#0000000000000100;	// ME TEMP CILINDRO 13
	D_2480 : real := +0.0;
	D_2481 : word := 2#0000000000000000;
	D_2482 : int  := +00001;
	D_2483 : int  := +00000;
	D_2484 : int  := +00000;
	D_2485 : word := B#(  0, 0);
	D_2486 : word := B#(000,000);
	D_2487 : word := 2#0000000000000000;
	D_2488 : int  := +00000;
	D_2489 : int  := +00000;
	D_2490 : word := B#(  1,  1);	// State (1)
	D_2491 : word := B#(  0,  1);	//
	D_2492 : word := B#(  5,  8);	//
	D_2493 : int  := +00200;	//
	D_2494 : word := 2#0000000000000000;	//
	D_2495 : word := B#(  0,  0);	//
	D_2496 : word := B#(  1,  1);	// State (2)
	D_2497 : word := B#(  0,  1);	//
	D_2498 : word := B#(  3,  4);	//
	D_2499 : int  := +00000;	//
	D_2500 : word := 2#0000000000000000;	//
	D_2501 : word := B#(  0,  0);	//
	D_2502 : word := B#(  1,  1);	// State (3)
	D_2503 : word := B#(  0,  0);	//
	D_2504 : word := B#(  0,  0);	//
	D_2505 : int  := +00000;	//
	D_2506 : word := 2#0000000000000000;	//
	D_2507 : word := B#(  0,  0);	//
	D_2508 : word := B#(  1,  1);	// State (16)
	D_2509 : word := B#(  0,  1);	//
	D_2510 : word := B#(  15,  12);	//
	D_2511 : int  := +00000;	//
	D_2512 : word := 2#0000000000000000;	//
	D_2513 : word := B#(  0,  0);	//
	D_2514 : real := 0.000000000000;	//
	D_2515 : real := 1300.000000000000;	//
	D_2516 : real := 0.000000000000;	//
	D_2517 : real := 0.000000000000;	//
	D_2518 : real := +0.0;	//
	D_2519 : int  := 00000;	//
	D_2520 : int  := 00000;	//
	D_2521 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_2522 : int  := 00000;	//
	D_2523 : int  := +00000;	//
	D_2524 : word  := B#(000,000);	//
	D_2525 : int  := +00000;	//
	D_2526 : real := 1110.000000000000;	// Limit (1)
	D_2527 : real := +0.0;	//
	D_2528 : int  := +00000;	//
	D_2529 : word := 2#0000000000000000;	//
	D_2530 : int := +00000;	//
	D_2531 : real := 1022.000000000000;	// Limit (2)
	D_2532 : real := +0.0;	//
	D_2533 : int  := +00000;	//
	D_2534 : word := 2#0000000000000000;	//
	D_2535 : int := +00000;	//
	D_2536 : word := B#(  2,  3);	//  010167D ( 02546 )
	D_2537 : word := 2#0000000000000100;	// ME CILINDRO TEMP 13 DESV.
	D_2538 : real := +0.0;
	D_2539 : word := 2#0000000000000000;
	D_2540 : int  := +00001;
	D_2541 : int  := +00000;
	D_2542 : int  := +00000;
	D_2543 : word := B#(  0, 0);
	D_2544 : word := B#(000,000);
	D_2545 : word := 2#0000000000000000;
	D_2546 : int  := +00000;
	D_2547 : int  := +00000;
	D_2548 : word := B#(  1,  1);	// State (1)
	D_2549 : word := B#(  0,  1);	//
	D_2550 : word := B#(  5,  8);	//
	D_2551 : int  := +00200;	//
	D_2552 : word := 2#0000000000000000;	//
	D_2553 : word := B#(  0,  0);	//
	D_2554 : word := B#(  1,  1);	// State (2)
	D_2555 : word := B#(  0,  0);	//
	D_2556 : word := B#(  0,  0);	//
	D_2557 : int  := +00000;	//
	D_2558 : word := 2#0000000000000000;	//
	D_2559 : word := B#(  0,  0);	//
	D_2560 : word := B#(  1,  1);	// State (3)
	D_2561 : word := B#(  0,  1);	//
	D_2562 : word := B#(  6,  1);	//
	D_2563 : int  := +00000;	//
	D_2564 : word := 2#0000000000000000;	//
	D_2565 : word := B#(  0,  0);	//
	D_2566 : word := B#(  1,  1);	// State (16)
	D_2567 : word := B#(  0,  1);	//
	D_2568 : word := B#(  15,  12);	//
	D_2569 : int  := +00000;	//
	D_2570 : word := 2#0000000000000000;	//
	D_2571 : word := B#(  0,  0);	//
	D_2572 : real := -150.000000000000;	//
	D_2573 : real := 150.000000000000;	//
	D_2574 : real := 0.000000000000;	//
	D_2575 : real := 1.500000000000;	//
	D_2576 : real := +0.0;	//
	D_2577 : int  := 00000;	//
	D_2578 : int  := 00000;	//
	D_2579 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_2580 : int  := 00000;	//
	D_2581 : int  := +00000;	//
	D_2582 : word  := B#(000,000);	//
	D_2583 : int  := +00000;	//
	D_2584 : real := 120.000000000000;	// Limit (1)
	D_2585 : real := +0.0;	//
	D_2586 : int  := +00000;	//
	D_2587 : word := 2#0000000000000000;	//
	D_2588 : int := +00000;	//
	D_2589 : real := -120.000000000000;	// Limit (2)
	D_2590 : real := +0.0;	//
	D_2591 : int  := +00000;	//
	D_2592 : word := 2#0000000000000000;	//
	D_2593 : int := +00000;	//
	D_2594 : word := B#(  2,  3);	//  010168 ( 02547 )
	D_2595 : word := 2#0000000000000100;	// ME TEMP CILINDRO 14
	D_2596 : real := +0.0;
	D_2597 : word := 2#0000000000000000;
	D_2598 : int  := +00001;
	D_2599 : int  := +00000;
	D_2600 : int  := +00000;
	D_2601 : word := B#(  0, 0);
	D_2602 : word := B#(000,000);
	D_2603 : word := 2#0000000000000000;
	D_2604 : int  := +00000;
	D_2605 : int  := +00000;
	D_2606 : word := B#(  1,  1);	// State (1)
	D_2607 : word := B#(  0,  1);	//
	D_2608 : word := B#(  5,  8);	//
	D_2609 : int  := +00200;	//
	D_2610 : word := 2#0000000000000000;	//
	D_2611 : word := B#(  0,  0);	//
	D_2612 : word := B#(  1,  1);	// State (2)
	D_2613 : word := B#(  0,  1);	//
	D_2614 : word := B#(  3,  4);	//
	D_2615 : int  := +00000;	//
	D_2616 : word := 2#0000000000000000;	//
	D_2617 : word := B#(  0,  0);	//
	D_2618 : word := B#(  1,  1);	// State (3)
	D_2619 : word := B#(  0,  0);	//
	D_2620 : word := B#(  0,  0);	//
	D_2621 : int  := +00000;	//
	D_2622 : word := 2#0000000000000000;	//
	D_2623 : word := B#(  0,  0);	//
	D_2624 : word := B#(  1,  1);	// State (16)
	D_2625 : word := B#(  0,  1);	//
	D_2626 : word := B#(  15,  12);	//
	D_2627 : int  := +00000;	//
	D_2628 : word := 2#0000000000000000;	//
	D_2629 : word := B#(  0,  0);	//
	D_2630 : real := 0.000000000000;	//
	D_2631 : real := 1300.000000000000;	//
	D_2632 : real := 0.000000000000;	//
	D_2633 : real := 0.000000000000;	//
	D_2634 : real := +0.0;	//
	D_2635 : int  := 00000;	//
	D_2636 : int  := 00000;	//
	D_2637 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_2638 : int  := 00000;	//
	D_2639 : int  := +00000;	//
	D_2640 : word  := B#(000,000);	//
	D_2641 : int  := +00000;	//
	D_2642 : real := 1110.000000000000;	// Limit (1)
	D_2643 : real := +0.0;	//
	D_2644 : int  := +00000;	//
	D_2645 : word := 2#0000000000000000;	//
	D_2646 : int := +00000;	//
	D_2647 : real := 1022.000000000000;	// Limit (2)
	D_2648 : real := +0.0;	//
	D_2649 : int  := +00000;	//
	D_2650 : word := 2#0000000000000000;	//
	D_2651 : int := +00000;	//
	D_2652 : word := B#(  2,  3);	//  010168D ( 02548 )
	D_2653 : word := 2#0000000000000100;	// ME CILINDRO TEMP 14 DESV.
	D_2654 : real := +0.0;
	D_2655 : word := 2#0000000000000000;
	D_2656 : int  := +00001;
	D_2657 : int  := +00000;
	D_2658 : int  := +00000;
	D_2659 : word := B#(  0, 0);
	D_2660 : word := B#(000,000);
	D_2661 : word := 2#0000000000000000;
	D_2662 : int  := +00000;
	D_2663 : int  := +00000;
	D_2664 : word := B#(  1,  1);	// State (1)
	D_2665 : word := B#(  0,  1);	//
	D_2666 : word := B#(  5,  8);	//
	D_2667 : int  := +00200;	//
	D_2668 : word := 2#0000000000000000;	//
	D_2669 : word := B#(  0,  0);	//
	D_2670 : word := B#(  1,  1);	// State (2)
	D_2671 : word := B#(  0,  0);	//
	D_2672 : word := B#(  0,  0);	//
	D_2673 : int  := +00000;	//
	D_2674 : word := 2#0000000000000000;	//
	D_2675 : word := B#(  0,  0);	//
	D_2676 : word := B#(  1,  1);	// State (3)
	D_2677 : word := B#(  0,  1);	//
	D_2678 : word := B#(  6,  1);	//
	D_2679 : int  := +00000;	//
	D_2680 : word := 2#0000000000000000;	//
	D_2681 : word := B#(  0,  0);	//
	D_2682 : word := B#(  1,  1);	// State (16)
	D_2683 : word := B#(  0,  1);	//
	D_2684 : word := B#(  15,  12);	//
	D_2685 : int  := +00000;	//
	D_2686 : word := 2#0000000000000000;	//
	D_2687 : word := B#(  0,  0);	//
	D_2688 : real := -150.000000000000;	//
	D_2689 : real := 150.000000000000;	//
	D_2690 : real := 0.000000000000;	//
	D_2691 : real := 1.500000000000;	//
	D_2692 : real := +0.0;	//
	D_2693 : int  := 00000;	//
	D_2694 : int  := 00000;	//
	D_2695 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_2696 : int  := 00000;	//
	D_2697 : int  := +00000;	//
	D_2698 : word  := B#(000,000);	//
	D_2699 : int  := +00000;	//
	D_2700 : real := 120.000000000000;	// Limit (1)
	D_2701 : real := +0.0;	//
	D_2702 : int  := +00000;	//
	D_2703 : word := 2#0000000000000000;	//
	D_2704 : int := +00000;	//
	D_2705 : real := -120.000000000000;	// Limit (2)
	D_2706 : real := +0.0;	//
	D_2707 : int  := +00000;	//
	D_2708 : word := 2#0000000000000000;	//
	D_2709 : int := +00000;	//
	D_2710 : word := B#(  2,  3);	//  010169 ( 02549 )
	D_2711 : word := 2#0000000000000100;	// ME TEMP CILINDRO 15
	D_2712 : real := +0.0;
	D_2713 : word := 2#0000000000000000;
	D_2714 : int  := +00001;
	D_2715 : int  := +00000;
	D_2716 : int  := +00000;
	D_2717 : word := B#(  0, 0);
	D_2718 : word := B#(000,000);
	D_2719 : word := 2#0000000000000000;
	D_2720 : int  := +00000;
	D_2721 : int  := +00000;
	D_2722 : word := B#(  1,  1);	// State (1)
	D_2723 : word := B#(  0,  1);	//
	D_2724 : word := B#(  5,  8);	//
	D_2725 : int  := +00200;	//
	D_2726 : word := 2#0000000000000000;	//
	D_2727 : word := B#(  0,  0);	//
	D_2728 : word := B#(  1,  1);	// State (2)
	D_2729 : word := B#(  0,  1);	//
	D_2730 : word := B#(  3,  4);	//
	D_2731 : int  := +00000;	//
	D_2732 : word := 2#0000000000000000;	//
	D_2733 : word := B#(  0,  0);	//
	D_2734 : word := B#(  1,  1);	// State (3)
	D_2735 : word := B#(  0,  0);	//
	D_2736 : word := B#(  0,  0);	//
	D_2737 : int  := +00000;	//
	D_2738 : word := 2#0000000000000000;	//
	D_2739 : word := B#(  0,  0);	//
	D_2740 : word := B#(  1,  1);	// State (16)
	D_2741 : word := B#(  0,  1);	//
	D_2742 : word := B#(  15,  12);	//
	D_2743 : int  := +00000;	//
	D_2744 : word := 2#0000000000000000;	//
	D_2745 : word := B#(  0,  0);	//
	D_2746 : real := 0.000000000000;	//
	D_2747 : real := 1300.000000000000;	//
	D_2748 : real := 0.000000000000;	//
	D_2749 : real := 0.000000000000;	//
	D_2750 : real := +0.0;	//
	D_2751 : int  := 00000;	//
	D_2752 : int  := 00000;	//
	D_2753 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_2754 : int  := 00000;	//
	D_2755 : int  := +00000;	//
	D_2756 : word  := B#(000,000);	//
	D_2757 : int  := +00000;	//
	D_2758 : real := 1110.000000000000;	// Limit (1)
	D_2759 : real := +0.0;	//
	D_2760 : int  := +00000;	//
	D_2761 : word := 2#0000000000000000;	//
	D_2762 : int := +00000;	//
	D_2763 : real := 1022.000000000000;	// Limit (2)
	D_2764 : real := +0.0;	//
	D_2765 : int  := +00000;	//
	D_2766 : word := 2#0000000000000000;	//
	D_2767 : int := +00000;	//
	D_2768 : word := B#(  2,  3);	//  010169D ( 02550 )
	D_2769 : word := 2#0000000000000100;	// ME CILINDRO TEMP 15 DESV.
	D_2770 : real := +0.0;
	D_2771 : word := 2#0000000000000000;
	D_2772 : int  := +00001;
	D_2773 : int  := +00000;
	D_2774 : int  := +00000;
	D_2775 : word := B#(  0, 0);
	D_2776 : word := B#(000,000);
	D_2777 : word := 2#0000000000000000;
	D_2778 : int  := +00000;
	D_2779 : int  := +00000;
	D_2780 : word := B#(  1,  1);	// State (1)
	D_2781 : word := B#(  0,  1);	//
	D_2782 : word := B#(  5,  8);	//
	D_2783 : int  := +00200;	//
	D_2784 : word := 2#0000000000000000;	//
	D_2785 : word := B#(  0,  0);	//
	D_2786 : word := B#(  1,  1);	// State (2)
	D_2787 : word := B#(  0,  0);	//
	D_2788 : word := B#(  0,  0);	//
	D_2789 : int  := +00000;	//
	D_2790 : word := 2#0000000000000000;	//
	D_2791 : word := B#(  0,  0);	//
	D_2792 : word := B#(  1,  1);	// State (3)
	D_2793 : word := B#(  0,  1);	//
	D_2794 : word := B#(  6,  1);	//
	D_2795 : int  := +00000;	//
	D_2796 : word := 2#0000000000000000;	//
	D_2797 : word := B#(  0,  0);	//
	D_2798 : word := B#(  1,  1);	// State (16)
	D_2799 : word := B#(  0,  1);	//
	D_2800 : word := B#(  15,  12);	//
	D_2801 : int  := +00000;	//
	D_2802 : word := 2#0000000000000000;	//
	D_2803 : word := B#(  0,  0);	//
	D_2804 : real := -150.000000000000;	//
	D_2805 : real := 150.000000000000;	//
	D_2806 : real := 0.000000000000;	//
	D_2807 : real := 1.500000000000;	//
	D_2808 : real := +0.0;	//
	D_2809 : int  := 00000;	//
	D_2810 : int  := 00000;	//
	D_2811 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_2812 : int  := 00000;	//
	D_2813 : int  := +00000;	//
	D_2814 : word  := B#(000,000);	//
	D_2815 : int  := +00000;	//
	D_2816 : real := 120.000000000000;	// Limit (1)
	D_2817 : real := +0.0;	//
	D_2818 : int  := +00000;	//
	D_2819 : word := 2#0000000000000000;	//
	D_2820 : int := +00000;	//
	D_2821 : real := -120.000000000000;	// Limit (2)
	D_2822 : real := +0.0;	//
	D_2823 : int  := +00000;	//
	D_2824 : word := 2#0000000000000000;	//
	D_2825 : int := +00000;	//
	D_2826 : word := B#(  2,  3);	//  010170 ( 02551 )
	D_2827 : word := 2#0000000000000100;	// ME TEMP CILINDRO 16
	D_2828 : real := +0.0;
	D_2829 : word := 2#0000000000000000;
	D_2830 : int  := +00001;
	D_2831 : int  := +00000;
	D_2832 : int  := +00000;
	D_2833 : word := B#(  0, 0);
	D_2834 : word := B#(000,000);
	D_2835 : word := 2#0000000000000000;
	D_2836 : int  := +00000;
	D_2837 : int  := +00000;
	D_2838 : word := B#(  1,  1);	// State (1)
	D_2839 : word := B#(  0,  1);	//
	D_2840 : word := B#(  5,  8);	//
	D_2841 : int  := +00200;	//
	D_2842 : word := 2#0000000000000000;	//
	D_2843 : word := B#(  0,  0);	//
	D_2844 : word := B#(  1,  1);	// State (2)
	D_2845 : word := B#(  0,  1);	//
	D_2846 : word := B#(  3,  4);	//
	D_2847 : int  := +00000;	//
	D_2848 : word := 2#0000000000000000;	//
	D_2849 : word := B#(  0,  0);	//
	D_2850 : word := B#(  1,  1);	// State (3)
	D_2851 : word := B#(  0,  0);	//
	D_2852 : word := B#(  0,  0);	//
	D_2853 : int  := +00000;	//
	D_2854 : word := 2#0000000000000000;	//
	D_2855 : word := B#(  0,  0);	//
	D_2856 : word := B#(  1,  1);	// State (16)
	D_2857 : word := B#(  0,  1);	//
	D_2858 : word := B#(  15,  12);	//
	D_2859 : int  := +00000;	//
	D_2860 : word := 2#0000000000000000;	//
	D_2861 : word := B#(  0,  0);	//
	D_2862 : real := 0.000000000000;	//
	D_2863 : real := 1300.000000000000;	//
	D_2864 : real := 0.000000000000;	//
	D_2865 : real := 0.000000000000;	//
	D_2866 : real := +0.0;	//
	D_2867 : int  := 00000;	//
	D_2868 : int  := 00000;	//
	D_2869 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_2870 : int  := 00000;	//
	D_2871 : int  := +00000;	//
	D_2872 : word  := B#(000,000);	//
	D_2873 : int  := +00000;	//
	D_2874 : real := 1110.000000000000;	// Limit (1)
	D_2875 : real := +0.0;	//
	D_2876 : int  := +00000;	//
	D_2877 : word := 2#0000000000000000;	//
	D_2878 : int := +00000;	//
	D_2879 : real := 1022.000000000000;	// Limit (2)
	D_2880 : real := +0.0;	//
	D_2881 : int  := +00000;	//
	D_2882 : word := 2#0000000000000000;	//
	D_2883 : int := +00000;	//
	D_2884 : word := B#(  2,  3);	//  010170D ( 02552 )
	D_2885 : word := 2#0000000000000100;	// ME CILINDRO TEMP 16 DESV.
	D_2886 : real := +0.0;
	D_2887 : word := 2#0000000000000000;
	D_2888 : int  := +00001;
	D_2889 : int  := +00000;
	D_2890 : int  := +00000;
	D_2891 : word := B#(  0, 0);
	D_2892 : word := B#(000,000);
	D_2893 : word := 2#0000000000000000;
	D_2894 : int  := +00000;
	D_2895 : int  := +00000;
	D_2896 : word := B#(  1,  1);	// State (1)
	D_2897 : word := B#(  0,  1);	//
	D_2898 : word := B#(  5,  8);	//
	D_2899 : int  := +00200;	//
	D_2900 : word := 2#0000000000000000;	//
	D_2901 : word := B#(  0,  0);	//
	D_2902 : word := B#(  1,  1);	// State (2)
	D_2903 : word := B#(  0,  0);	//
	D_2904 : word := B#(  0,  0);	//
	D_2905 : int  := +00000;	//
	D_2906 : word := 2#0000000000000000;	//
	D_2907 : word := B#(  0,  0);	//
	D_2908 : word := B#(  1,  1);	// State (3)
	D_2909 : word := B#(  0,  1);	//
	D_2910 : word := B#(  6,  1);	//
	D_2911 : int  := +00000;	//
	D_2912 : word := 2#0000000000000000;	//
	D_2913 : word := B#(  0,  0);	//
	D_2914 : word := B#(  1,  1);	// State (16)
	D_2915 : word := B#(  0,  1);	//
	D_2916 : word := B#(  15,  12);	//
	D_2917 : int  := +00000;	//
	D_2918 : word := 2#0000000000000000;	//
	D_2919 : word := B#(  0,  0);	//
	D_2920 : real := -150.000000000000;	//
	D_2921 : real := 150.000000000000;	//
	D_2922 : real := 0.000000000000;	//
	D_2923 : real := 1.500000000000;	//
	D_2924 : real := +0.0;	//
	D_2925 : int  := 00000;	//
	D_2926 : int  := 00000;	//
	D_2927 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_2928 : int  := 00000;	//
	D_2929 : int  := +00000;	//
	D_2930 : word  := B#(000,000);	//
	D_2931 : int  := +00000;	//
	D_2932 : real := 120.000000000000;	// Limit (1)
	D_2933 : real := +0.0;	//
	D_2934 : int  := +00000;	//
	D_2935 : word := 2#0000000000000000;	//
	D_2936 : int := +00000;	//
	D_2937 : real := -120.000000000000;	// Limit (2)
	D_2938 : real := +0.0;	//
	D_2939 : int  := +00000;	//
	D_2940 : word := 2#0000000000000000;	//
	D_2941 : int := +00000;	//
	D_2942 : word := B#(  2,  3);	//  010171 ( 02553 )
	D_2943 : word := 2#0000000000000100;	// ME TEMP PROMEDIO
	D_2944 : real := +0.0;
	D_2945 : word := 2#0000000000000000;
	D_2946 : int  := +00001;
	D_2947 : int  := +00000;
	D_2948 : int  := +00000;
	D_2949 : word := B#(  0, 0);
	D_2950 : word := B#(000,000);
	D_2951 : word := 2#0000000000000000;
	D_2952 : int  := +00000;
	D_2953 : int  := +00000;
	D_2954 : word := B#(  1,  1);	// State (1)
	D_2955 : word := B#(  0,  1);	//
	D_2956 : word := B#(  5,  8);	//
	D_2957 : int  := +00198;	//
	D_2958 : word := 2#0000000000000000;	//
	D_2959 : word := B#(  0,  0);	//
	D_2960 : word := B#(  1,  1);	// State (2)
	D_2961 : word := B#(  0,  1);	//
	D_2962 : word := B#(  3,  4);	//
	D_2963 : int  := +00000;	//
	D_2964 : word := 2#0000000000000000;	//
	D_2965 : word := B#(  0,  0);	//
	D_2966 : word := B#(  1,  1);	// State (3)
	D_2967 : word := B#(  0,  0);	//
	D_2968 : word := B#(  0,  0);	//
	D_2969 : int  := +00000;	//
	D_2970 : word := 2#0000000000000000;	//
	D_2971 : word := B#(  0,  0);	//
	D_2972 : word := B#(  1,  1);	// State (16)
	D_2973 : word := B#(  0,  1);	//
	D_2974 : word := B#(  15,  12);	//
	D_2975 : int  := +00000;	//
	D_2976 : word := 2#0000000000000000;	//
	D_2977 : word := B#(  0,  0);	//
	D_2978 : real := 0.000000000000;	//
	D_2979 : real := 1500.000000000000;	//
	D_2980 : real := 0.000000000000;	//
	D_2981 : real := 7.500000000000;	//
	D_2982 : real := +0.0;	//
	D_2983 : int  := 00000;	//
	D_2984 : int  := 00000;	//
	D_2985 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_2986 : int  := 00000;	//
	D_2987 : int  := +00000;	//
	D_2988 : word  := B#(000,000);	//
	D_2989 : int  := +00000;	//
	D_2990 : real := 1112.000000000000;	// Limit (1)
	D_2991 : real := +0.0;	//
	D_2992 : int  := +00000;	//
	D_2993 : word := 2#0000000000000000;	//
	D_2994 : int := +00000;	//
	D_2995 : real := 1022.000000000000;	// Limit (2)
	D_2996 : real := +0.0;	//
	D_2997 : int  := +00000;	//
	D_2998 : word := 2#0000000000000000;	//
	D_2999 : int := +00000;	//
	D_3000 : word := B#(  2,  2);	//  010172 ( 02554 )
	D_3001 : word := 2#0000000000000100;	// ME PRES DIF ACEITE LUB EN FILT
	D_3002 : real := +0.0;
	D_3003 : word := 2#0000000000000000;
	D_3004 : int  := +00001;
	D_3005 : int  := +00000;
	D_3006 : int  := +00000;
	D_3007 : word := B#(  0, 0);
	D_3008 : word := B#(000,000);
	D_3009 : word := 2#0000000000000000;
	D_3010 : int  := +00000;
	D_3011 : int  := +00000;
	D_3012 : word := B#(  1,  1);	// State (1)
	D_3013 : word := B#(  0,  1);	//
	D_3014 : word := B#(  5,  8);	//
	D_3015 : int  := +00198;	//
	D_3016 : word := 2#0000000000000000;	//
	D_3017 : word := B#(  0,  0);	//
	D_3018 : word := B#(  1,  1);	// State (2)
	D_3019 : word := B#(  0,  0);	//
	D_3020 : word := B#(  0,  0);	//
	D_3021 : int  := +00000;	//
	D_3022 : word := 2#0000000000000000;	//
	D_3023 : word := B#(  0,  0);	//
	D_3024 : word := B#(  1,  1);	// State (16)
	D_3025 : word := B#(  0,  1);	//
	D_3026 : word := B#(  15,  12);	//
	D_3027 : int  := +00000;	//
	D_3028 : word := 2#0000000000000000;	//
	D_3029 : word := B#(  0,  0);	//
	D_3030 : real := -15.000000000000;	//
	D_3031 : real := 15.000000000000;	//
	D_3032 : real := 0.000000000000;	//
	D_3033 : real := 0.150000000000;	//
	D_3034 : real := +0.0;	//
	D_3035 : int  := 00000;	//
	D_3036 : int  := 00000;	//
	D_3037 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_3038 : int  := 00000;	//
	D_3039 : int  := +00000;	//
	D_3040 : word  := B#(000,000);	//
	D_3041 : int  := +00000;	//
	D_3042 : real := 10.000000000000;	// Limit (1)
	D_3043 : real := +0.0;	//
	D_3044 : int  := +00000;	//
	D_3045 : word := 2#0000000000000000;	//
	D_3046 : int := +00000;	//
	D_3047 : word := B#(  2,  2);	//  010173 ( 02555 )
	D_3048 : word := 2#0000000000000100;	// ME PRES DIF COMBUSTIBL EN FILT
	D_3049 : real := +0.0;
	D_3050 : word := 2#0000000000000000;
	D_3051 : int  := +00001;
	D_3052 : int  := +00000;
	D_3053 : int  := +00000;
	D_3054 : word := B#(  0, 0);
	D_3055 : word := B#(000,000);
	D_3056 : word := 2#0000000000000000;
	D_3057 : int  := +00000;
	D_3058 : int  := +00000;
	D_3059 : word := B#(  1,  1);	// State (1)
	D_3060 : word := B#(  0,  1);	//
	D_3061 : word := B#(  5,  8);	//
	D_3062 : int  := +00198;	//
	D_3063 : word := 2#0000000000000000;	//
	D_3064 : word := B#(  0,  0);	//
	D_3065 : word := B#(  1,  1);	// State (2)
	D_3066 : word := B#(  0,  0);	//
	D_3067 : word := B#(  0,  0);	//
	D_3068 : int  := +00000;	//
	D_3069 : word := 2#0000000000000000;	//
	D_3070 : word := B#(  0,  0);	//
	D_3071 : word := B#(  1,  1);	// State (16)
	D_3072 : word := B#(  0,  1);	//
	D_3073 : word := B#(  15,  12);	//
	D_3074 : int  := +00000;	//
	D_3075 : word := 2#0000000000000000;	//
	D_3076 : word := B#(  0,  0);	//
	D_3077 : real := -15.000000000000;	//
	D_3078 : real := 15.000000000000;	//
	D_3079 : real := 0.000000000000;	//
	D_3080 : real := 0.150000000000;	//
	D_3081 : real := +0.0;	//
	D_3082 : int  := 00000;	//
	D_3083 : int  := 00000;	//
	D_3084 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_3085 : int  := 00000;	//
	D_3086 : int  := +00000;	//
	D_3087 : word  := B#(000,000);	//
	D_3088 : int  := +00000;	//
	D_3089 : real := 10.000000000000;	// Limit (1)
	D_3090 : real := +0.0;	//
	D_3091 : int  := +00000;	//
	D_3092 : word := 2#0000000000000000;	//
	D_3093 : int := +00000;	//
	D_3094 : word := B#(  2,  2);	//  010174 ( 02556 )
	D_3095 : word := 2#0000000000000100;	// ME TEMP ACEITE CAJA ENGRANES
	D_3096 : real := +0.0;
	D_3097 : word := 2#0000000000000000;
	D_3098 : int  := +00001;
	D_3099 : int  := +00000;
	D_3100 : int  := +00000;
	D_3101 : word := B#(  0, 0);
	D_3102 : word := B#(000,000);
	D_3103 : word := 2#0000000000000000;
	D_3104 : int  := +00000;
	D_3105 : int  := +00000;
	D_3106 : word := B#(  1,  1);	// State (1)
	D_3107 : word := B#(  0,  1);	//
	D_3108 : word := B#(  5,  8);	//
	D_3109 : int  := +00200;	//
	D_3110 : word := 2#0000000000000000;	//
	D_3111 : word := B#(  0,  0);	//
	D_3112 : word := B#(  1,  1);	// State (2)
	D_3113 : word := B#(  0,  0);	//
	D_3114 : word := B#(  0,  0);	//
	D_3115 : int  := +00000;	//
	D_3116 : word := 2#0000000000000000;	//
	D_3117 : word := B#(  0,  0);	//
	D_3118 : word := B#(  1,  1);	// State (16)
	D_3119 : word := B#(  0,  1);	//
	D_3120 : word := B#(  15,  12);	//
	D_3121 : int  := +00000;	//
	D_3122 : word := 2#0000000000000000;	//
	D_3123 : word := B#(  0,  0);	//
	D_3124 : real := 0.000000000000;	//
	D_3125 : real := 300.000000000000;	//
	D_3126 : real := 0.000000000000;	//
	D_3127 : real := 1.500000000000;	//
	D_3128 : real := +0.0;	//
	D_3129 : int  := 00000;	//
	D_3130 : int  := 00000;	//
	D_3131 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_3132 : int  := 00000;	//
	D_3133 : int  := +00000;	//
	D_3134 : word  := B#(000,000);	//
	D_3135 : int  := +00000;	//
	D_3136 : real := 194.000000000000;	// Limit (1)
	D_3137 : real := +0.0;	//
	D_3138 : int  := +00000;	//
	D_3139 : word := 2#0000000000000000;	//
	D_3140 : int := +00000;	//
	D_3141 : word := B#(  2,  3);	//  010234 ( 02557 )
	D_3142 : word := 2#0000000000000100;	// MB CAJA ENGRANES PRES LUB
	D_3143 : real := +0.0;
	D_3144 : word := 2#0000000000000000;
	D_3145 : int  := +00000;
	D_3146 : int  := +00000;
	D_3147 : int  := +00000;
	D_3148 : word := B#(  0, 0);
	D_3149 : word := B#(000,000);
	D_3150 : word := 2#0000000000000000;
	D_3151 : int  := +00000;
	D_3152 : int  := +00000;
	D_3153 : word := B#(  1,  1);	// State (1)
	D_3154 : word := B#(  0,  0);	//
	D_3155 : word := B#(  0,  0);	//
	D_3156 : int  := +00000;	//
	D_3157 : word := 2#0000000000000000;	//
	D_3158 : word := B#(  0,  0);	//
	D_3159 : word := B#(  1,  1);	// State (2)
	D_3160 : word := B#(  0,  1);	//
	D_3161 : word := B#(  3,  5);	//
	D_3162 : int  := +00000;	//
	D_3163 : word := 2#0000000000000000;	//
	D_3164 : word := B#(  0,  0);	//
	D_3165 : word := B#(  1,  1);	// State (3)
	D_3166 : word := B#(  0,  1);	//
	D_3167 : word := B#(  5,  9);	//
	D_3168 : int  := +00000;	//
	D_3169 : word := 2#0000000000000000;	//
	D_3170 : word := B#(  0,  0);	//
	D_3171 : word := B#(  1,  1);	// State (16)
	D_3172 : word := B#(  0,  1);	//
	D_3173 : word := B#(  15,  12);	//
	D_3174 : int  := +00000;	//
	D_3175 : word := 2#0000000000000000;	//
	D_3176 : word := B#(  0,  0);	//
	D_3177 : real := 0.000000000000;	//
	D_3178 : real := 350.000000000000;	//
	D_3179 : real := 0.000000000000;	//
	D_3180 : real := 1.750000000000;	//
	D_3181 : real := +0.0;	//
	D_3182 : int  := 00000;	//
	D_3183 : int  := 00000;	//
	D_3184 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_3185 : int  := 00000;	//
	D_3186 : int  := +00000;	//
	D_3187 : word  := B#(000,000);	//
	D_3188 : int  := +00000;	//
	D_3189 : real := 232.000000000000;	// Limit (1)
	D_3190 : real := +0.0;	//
	D_3191 : int  := +00000;	//
	D_3192 : word := 2#0000000000000000;	//
	D_3193 : int := +00000;	//
	D_3194 : real := 230.000000000000;	// Limit (2)
	D_3195 : real := +0.0;	//
	D_3196 : int  := +00000;	//
	D_3197 : word := 2#0000000000000000;	//
	D_3198 : int := +00000;	//
	D_3199 : word := B#(  2,  5);	//  010235 ( 02558 )
	D_3200 : word := 2#0000000000000100;	// MB PRES ACEITE DESPUES DEL F.
	D_3201 : real := +0.0;
	D_3202 : word := 2#0000000000000000;
	D_3203 : int  := +00000;
	D_3204 : int  := +00000;
	D_3205 : int  := +00000;
	D_3206 : word := B#(  0, 0);
	D_3207 : word := B#(000,000);
	D_3208 : word := 2#0000000000000000;
	D_3209 : int  := +00000;
	D_3210 : int  := +00000;
	D_3211 : word := B#(  1,  1);	// State (1)
	D_3212 : word := B#(  0,  0);	//
	D_3213 : word := B#(  0,  0);	//
	D_3214 : int  := +00000;	//
	D_3215 : word := 2#0000000000000000;	//
	D_3216 : word := B#(  0,  0);	//
	D_3217 : word := B#(  1,  1);	// State (2)
	D_3218 : word := B#(  0,  1);	//
	D_3219 : word := B#(  3,  5);	//
	D_3220 : int  := +00000;	//
	D_3221 : word := 2#0000000000000000;	//
	D_3222 : word := B#(  0,  0);	//
	D_3223 : word := B#(  1,  1);	// State (3)
	D_3224 : word := B#(  0,  1);	//
	D_3225 : word := B#(  5,  9);	//
	D_3226 : int  := +00000;	//
	D_3227 : word := 2#0000000000000000;	//
	D_3228 : word := B#(  0,  0);	//
	D_3229 : word := B#(  1,  1);	// State (4)
	D_3230 : word := B#(  0,  1);	//
	D_3231 : word := B#(  3,  5);	//
	D_3232 : int  := +00000;	//
	D_3233 : word := 2#0000000000000000;	//
	D_3234 : word := B#(  0,  0);	//
	D_3235 : word := B#(  1,  1);	// State (5)
	D_3236 : word := B#(  0,  1);	//
	D_3237 : word := B#(  5,  9);	//
	D_3238 : int  := +00000;	//
	D_3239 : word := 2#0000000000000000;	//
	D_3240 : word := B#(  0,  0);	//
	D_3241 : word := B#(  1,  1);	// State (16)
	D_3242 : word := B#(  0,  1);	//
	D_3243 : word := B#(  15,  12);	//
	D_3244 : int  := +00000;	//
	D_3245 : word := 2#0000000000000000;	//
	D_3246 : word := B#(  0,  0);	//
	D_3247 : real := 0.000000000000;	//
	D_3248 : real := 145.000000000000;	//
	D_3249 : real := 1.450000000000;	//
	D_3250 : real := 1.450000000000;	//
	D_3251 : real := +0.0;	//
	D_3252 : int  := 00000;	//
	D_3253 : int  := 00000;	//
	D_3254 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_3255 : int  := 00000;	//
	D_3256 : int  := +00000;	//
	D_3257 : word  := B#(000,000);	//
	D_3258 : int  := +00000;	//
	D_3259 : real := 46.000000000000;	// Limit (1)
	D_3260 : real := +0.0;	//
	D_3261 : int  := +00000;	//
	D_3262 : word := 2#0000000000000000;	//
	D_3263 : int := +00000;	//
	D_3264 : real := 38.000000000000;	// Limit (2)
	D_3265 : real := +0.0;	//
	D_3266 : int  := +00000;	//
	D_3267 : word := 2#0000000000000000;	//
	D_3268 : int := +00000;	//
	D_3269 : real := 17.000000000000;	// Limit (3)
	D_3270 : real := +0.0;	//
	D_3271 : int  := +00000;	//
	D_3272 : word := 2#0000000000000000;	//
	D_3273 : int := +00000;	//
	D_3274 : real := 15.000000000000;	// Limit (4)
	D_3275 : real := +0.0;	//
	D_3276 : int  := +00000;	//
	D_3277 : word := 2#0000000000000000;	//
	D_3278 : int := +00000;	//
	D_3279 : word := B#(  2,  1);	//  010236 ( 02559 )
	D_3280 : word := 2#0000000000000100;	// MB PRES ACEITE ANTES DEL F.
	D_3281 : real := +0.0;
	D_3282 : word := 2#0000000000000000;
	D_3283 : int  := +00000;
	D_3284 : int  := +00000;
	D_3285 : int  := +00000;
	D_3286 : word := B#(  0, 0);
	D_3287 : word := B#(000,000);
	D_3288 : word := 2#0000000000000000;
	D_3289 : int  := +00000;
	D_3290 : int  := +00000;
	D_3291 : word := B#(  1,  1);	// State (1)
	D_3292 : word := B#(  0,  0);	//
	D_3293 : word := B#(  0,  0);	//
	D_3294 : int  := +00000;	//
	D_3295 : word := 2#0000000000000000;	//
	D_3296 : word := B#(  0,  0);	//
	D_3297 : word := B#(  1,  1);	// State (16)
	D_3298 : word := B#(  0,  1);	//
	D_3299 : word := B#(  15,  12);	//
	D_3300 : int  := +00000;	//
	D_3301 : word := 2#0000000000000000;	//
	D_3302 : word := B#(  0,  0);	//
	D_3303 : real := 0.000000000000;	//
	D_3304 : real := 145.000000000000;	//
	D_3305 : real := 0.000000000000;	//
	D_3306 : real := 0.725000000000;	//
	D_3307 : real := +0.0;	//
	D_3308 : int  := 00000;	//
	D_3309 : int  := 00000;	//
	D_3310 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_3311 : int  := 00000;	//
	D_3312 : int  := +00000;	//
	D_3313 : word  := B#(000,000);	//
	D_3314 : int  := +00000;	//
	D_3315 : word := B#(  2,  3);	//  010237 ( 02560 )
	D_3316 : word := 2#0000000000000100;	// MB PRES COMB DESPUES FILTRO
	D_3317 : real := +0.0;
	D_3318 : word := 2#0000000000000000;
	D_3319 : int  := +00000;
	D_3320 : int  := +00000;
	D_3321 : int  := +00000;
	D_3322 : word := B#(  0, 0);
	D_3323 : word := B#(000,000);
	D_3324 : word := 2#0000000000000000;
	D_3325 : int  := +00000;
	D_3326 : int  := +00000;
	D_3327 : word := B#(  1,  1);	// State (1)
	D_3328 : word := B#(  0,  0);	//
	D_3329 : word := B#(  0,  0);	//
	D_3330 : int  := +00000;	//
	D_3331 : word := 2#0000000000000000;	//
	D_3332 : word := B#(  0,  0);	//
	D_3333 : word := B#(  1,  1);	// State (2)
	D_3334 : word := B#(  0,  1);	//
	D_3335 : word := B#(  3,  5);	//
	D_3336 : int  := +00000;	//
	D_3337 : word := 2#0000000000000000;	//
	D_3338 : word := B#(  0,  0);	//
	D_3339 : word := B#(  1,  1);	// State (3)
	D_3340 : word := B#(  0,  1);	//
	D_3341 : word := B#(  5,  9);	//
	D_3342 : int  := +00000;	//
	D_3343 : word := 2#0000000000000000;	//
	D_3344 : word := B#(  0,  0);	//
	D_3345 : word := B#(  1,  1);	// State (16)
	D_3346 : word := B#(  0,  1);	//
	D_3347 : word := B#(  15,  12);	//
	D_3348 : int  := +00000;	//
	D_3349 : word := 2#0000000000000000;	//
	D_3350 : word := B#(  0,  0);	//
	D_3351 : real := 0.000000000000;	//
	D_3352 : real := 145.000000000000;	//
	D_3353 : real := 0.000000000000;	//
	D_3354 : real := 0.725000000000;	//
	D_3355 : real := +0.0;	//
	D_3356 : int  := 00000;	//
	D_3357 : int  := 00000;	//
	D_3358 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_3359 : int  := 00000;	//
	D_3360 : int  := +00000;	//
	D_3361 : word  := B#(000,000);	//
	D_3362 : int  := +00000;	//
	D_3363 : real := 35.000000000000;	// Limit (1)
	D_3364 : real := +0.0;	//
	D_3365 : int  := +00000;	//
	D_3366 : word := 2#0000000000000000;	//
	D_3367 : int := +00000;	//
	D_3368 : real := 15.250000000000;	// Limit (2)
	D_3369 : real := +0.0;	//
	D_3370 : int  := +00000;	//
	D_3371 : word := 2#0000000000000000;	//
	D_3372 : int := +00000;	//
	D_3373 : word := B#(  2,  1);	//  010238 ( 02561 )
	D_3374 : word := 2#0000000000000100;	// MB PRES COMB ANTES  DEL FILTRO
	D_3375 : real := +0.0;
	D_3376 : word := 2#0000000000000000;
	D_3377 : int  := +00000;
	D_3378 : int  := +00000;
	D_3379 : int  := +00000;
	D_3380 : word := B#(  0, 0);
	D_3381 : word := B#(000,000);
	D_3382 : word := 2#0000000000000000;
	D_3383 : int  := +00000;
	D_3384 : int  := +00000;
	D_3385 : word := B#(  1,  1);	// State (1)
	D_3386 : word := B#(  0,  0);	//
	D_3387 : word := B#(  0,  0);	//
	D_3388 : int  := +00000;	//
	D_3389 : word := 2#0000000000000000;	//
	D_3390 : word := B#(  0,  0);	//
	D_3391 : word := B#(  1,  1);	// State (16)
	D_3392 : word := B#(  0,  1);	//
	D_3393 : word := B#(  15,  12);	//
	D_3394 : int  := +00000;	//
	D_3395 : word := 2#0000000000000000;	//
	D_3396 : word := B#(  0,  0);	//
	D_3397 : real := 0.000000000000;	//
	D_3398 : real := 145.000000000000;	//
	D_3399 : real := 0.000000000000;	//
	D_3400 : real := 0.725000000000;	//
	D_3401 : real := +0.0;	//
	D_3402 : int  := 00000;	//
	D_3403 : int  := 00000;	//
	D_3404 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_3405 : int  := 00000;	//
	D_3406 : int  := +00000;	//
	D_3407 : word  := B#(000,000);	//
	D_3408 : int  := +00000;	//
	D_3409 : word := B#(  2,  2);	//  010239 ( 02562 )
	D_3410 : word := 2#0000000000000100;	// MB PRES AGUA DE MAR
	D_3411 : real := +0.0;
	D_3412 : word := 2#0000000000000000;
	D_3413 : int  := +00000;
	D_3414 : int  := +00000;
	D_3415 : int  := +00000;
	D_3416 : word := B#(  0, 0);
	D_3417 : word := B#(000,000);
	D_3418 : word := 2#0000000000000000;
	D_3419 : int  := +00000;
	D_3420 : int  := +00000;
	D_3421 : word := B#(  1,  1);	// State (1)
	D_3422 : word := B#(  0,  0);	//
	D_3423 : word := B#(  0,  0);	//
	D_3424 : int  := +00000;	//
	D_3425 : word := 2#0000000000000000;	//
	D_3426 : word := B#(  0,  0);	//
	D_3427 : word := B#(  1,  1);	// State (2)
	D_3428 : word := B#(  0,  1);	//
	D_3429 : word := B#(  3,  5);	//
	D_3430 : int  := +00000;	//
	D_3431 : word := 2#0000000000000000;	//
	D_3432 : word := B#(  0,  0);	//
	D_3433 : word := B#(  1,  1);	// State (16)
	D_3434 : word := B#(  0,  1);	//
	D_3435 : word := B#(  15,  12);	//
	D_3436 : int  := +00000;	//
	D_3437 : word := 2#0000000000000000;	//
	D_3438 : word := B#(  0,  0);	//
	D_3439 : real := 0.000000000000;	//
	D_3440 : real := 145.000000000000;	//
	D_3441 : real := 0.000000000000;	//
	D_3442 : real := 0.725000000000;	//
	D_3443 : real := +0.0;	//
	D_3444 : int  := 00000;	//
	D_3445 : int  := 00000;	//
	D_3446 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_3447 : int  := 00000;	//
	D_3448 : int  := +00000;	//
	D_3449 : word  := B#(000,000);	//
	D_3450 : int  := +00000;	//
	D_3451 : real := 5.000000000000;	// Limit (1)
	D_3452 : real := +0.0;	//
	D_3453 : int  := +00000;	//
	D_3454 : word := 2#0000000000000000;	//
	D_3455 : int := +00000;	//
	D_3456 : word := B#(  2,  2);	//  010240 ( 02563 )
	D_3457 : word := 2#0000000000000100;	// MB PRES AIRE DE ARRANQUE
	D_3458 : real := +0.0;
	D_3459 : word := 2#0000000000000000;
	D_3460 : int  := +00000;
	D_3461 : int  := +00000;
	D_3462 : int  := +00000;
	D_3463 : word := B#(  0, 0);
	D_3464 : word := B#(000,000);
	D_3465 : word := 2#0000000000000000;
	D_3466 : int  := +00000;
	D_3467 : int  := +00000;
	D_3468 : word := B#(  1,  1);	// State (1)
	D_3469 : word := B#(  0,  0);	//
	D_3470 : word := B#(  0,  0);	//
	D_3471 : int  := +00000;	//
	D_3472 : word := 2#0000000000000000;	//
	D_3473 : word := B#(  0,  0);	//
	D_3474 : word := B#(  1,  1);	// State (2)
	D_3475 : word := B#(  0,  1);	//
	D_3476 : word := B#(  5,  9);	//
	D_3477 : int  := +00000;	//
	D_3478 : word := 2#0000000000000000;	//
	D_3479 : word := B#(  0,  0);	//
	D_3480 : word := B#(  1,  1);	// State (16)
	D_3481 : word := B#(  0,  1);	//
	D_3482 : word := B#(  15,  12);	//
	D_3483 : int  := +00000;	//
	D_3484 : word := 2#0000000000000000;	//
	D_3485 : word := B#(  0,  0);	//
	D_3486 : real := 0.000000000000;	//
	D_3487 : real := 400.000000000000;	//
	D_3488 : real := 0.000000000000;	//
	D_3489 : real := 2.000000000000;	//
	D_3490 : real := +0.0;	//
	D_3491 : int  := 00000;	//
	D_3492 : int  := 00000;	//
	D_3493 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_3494 : int  := 00000;	//
	D_3495 : int  := +00000;	//
	D_3496 : word  := B#(000,000);	//
	D_3497 : int  := +00000;	//
	D_3498 : real := 110.000000000000;	// Limit (1)
	D_3499 : real := +0.0;	//
	D_3500 : int  := +00000;	//
	D_3501 : word := 2#0000000000000000;	//
	D_3502 : int := +00000;	//
	D_3503 : word := B#(  2,  3);	//  010241 ( 02564 )
	D_3504 : word := 2#0000000000000100;	// MB PRES  AGUA DE CAMISAS
	D_3505 : real := +0.0;
	D_3506 : word := 2#0000000000000000;
	D_3507 : int  := +00000;
	D_3508 : int  := +00000;
	D_3509 : int  := +00000;
	D_3510 : word := B#(  0, 0);
	D_3511 : word := B#(000,000);
	D_3512 : word := 2#0000000000000000;
	D_3513 : int  := +00000;
	D_3514 : int  := +00000;
	D_3515 : word := B#(  1,  1);	// State (1)
	D_3516 : word := B#(  0,  0);	//
	D_3517 : word := B#(  0,  0);	//
	D_3518 : int  := +00000;	//
	D_3519 : word := 2#0000000000000000;	//
	D_3520 : word := B#(  0,  0);	//
	D_3521 : word := B#(  1,  1);	// State (2)
	D_3522 : word := B#(  0,  1);	//
	D_3523 : word := B#(  3,  5);	//
	D_3524 : int  := +00000;	//
	D_3525 : word := 2#0000000000000000;	//
	D_3526 : word := B#(  0,  0);	//
	D_3527 : word := B#(  1,  1);	// State (3)
	D_3528 : word := B#(  0,  1);	//
	D_3529 : word := B#(  5,  9);	//
	D_3530 : int  := +00000;	//
	D_3531 : word := 2#0000000000000000;	//
	D_3532 : word := B#(  0,  0);	//
	D_3533 : word := B#(  1,  1);	// State (16)
	D_3534 : word := B#(  0,  1);	//
	D_3535 : word := B#(  15,  12);	//
	D_3536 : int  := +00000;	//
	D_3537 : word := 2#0000000000000000;	//
	D_3538 : word := B#(  0,  0);	//
	D_3539 : real := 0.000000000000;	//
	D_3540 : real := 145.000000000000;	//
	D_3541 : real := 0.000000000000;	//
	D_3542 : real := 0.725000000000;	//
	D_3543 : real := +0.0;	//
	D_3544 : int  := 00000;	//
	D_3545 : int  := 00000;	//
	D_3546 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_3547 : int  := 00000;	//
	D_3548 : int  := +00000;	//
	D_3549 : word  := B#(000,000);	//
	D_3550 : int  := +00000;	//
	D_3551 : real := 5.000000000000;	// Limit (1)
	D_3552 : real := +0.0;	//
	D_3553 : int  := +00000;	//
	D_3554 : word := 2#0000000000000000;	//
	D_3555 : int := +00000;	//
	D_3556 : real := 3.000000000000;	// Limit (2)
	D_3557 : real := +0.0;	//
	D_3558 : int  := +00000;	//
	D_3559 : word := 2#0000000000000000;	//
	D_3560 : int := +00000;	//
	D_3561 : word := B#(  2,  2);	//  010242 ( 02565 )
	D_3562 : word := 2#0000000000000100;	// MB PRES DE BOMBA AC/OC
	D_3563 : real := +0.0;
	D_3564 : word := 2#0000000000000000;
	D_3565 : int  := +00000;
	D_3566 : int  := +00000;
	D_3567 : int  := +00000;
	D_3568 : word := B#(  0, 0);
	D_3569 : word := B#(000,000);
	D_3570 : word := 2#0000000000000000;
	D_3571 : int  := +00000;
	D_3572 : int  := +00000;
	D_3573 : word := B#(  1,  1);	// State (1)
	D_3574 : word := B#(  0,  0);	//
	D_3575 : word := B#(  0,  0);	//
	D_3576 : int  := +00000;	//
	D_3577 : word := 2#0000000000000000;	//
	D_3578 : word := B#(  0,  0);	//
	D_3579 : word := B#(  1,  1);	// State (2)
	D_3580 : word := B#(  0,  1);	//
	D_3581 : word := B#(  5,  9);	//
	D_3582 : int  := +00000;	//
	D_3583 : word := 2#0000000000000000;	//
	D_3584 : word := B#(  0,  0);	//
	D_3585 : word := B#(  1,  1);	// State (16)
	D_3586 : word := B#(  0,  1);	//
	D_3587 : word := B#(  15,  12);	//
	D_3588 : int  := +00000;	//
	D_3589 : word := 2#0000000000000000;	//
	D_3590 : word := B#(  0,  0);	//
	D_3591 : real := 0.000000000000;	//
	D_3592 : real := 145.000000000000;	//
	D_3593 : real := 0.000000000000;	//
	D_3594 : real := 0.725000000000;	//
	D_3595 : real := +0.0;	//
	D_3596 : int  := 00000;	//
	D_3597 : int  := 00000;	//
	D_3598 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_3599 : int  := 00000;	//
	D_3600 : int  := +00000;	//
	D_3601 : word  := B#(000,000);	//
	D_3602 : int  := +00000;	//
	D_3603 : real := 5.000000000000;	// Limit (1)
	D_3604 : real := +0.0;	//
	D_3605 : int  := +00000;	//
	D_3606 : word := 2#0000000000000000;	//
	D_3607 : int := +00000;	//
	D_3608 : word := B#(  2,  2);	//  010243 ( 02566 )
	D_3609 : word := 2#0000000000000100;	// MB PRES AIRE ENTRADA AL MULT
	D_3610 : real := +0.0;
	D_3611 : word := 2#0000000000000000;
	D_3612 : int  := +00000;
	D_3613 : int  := +00000;
	D_3614 : int  := +00000;
	D_3615 : word := B#(  0, 0);
	D_3616 : word := B#(000,000);
	D_3617 : word := 2#0000000000000000;
	D_3618 : int  := +00000;
	D_3619 : int  := +00000;
	D_3620 : word := B#(  1,  1);	// State (1)
	D_3621 : word := B#(  0,  1);	//
	D_3622 : word := B#(  5,  8);	//
	D_3623 : int  := +00000;	//
	D_3624 : word := 2#0000000000000000;	//
	D_3625 : word := B#(  0,  0);	//
	D_3626 : word := B#(  1,  1);	// State (2)
	D_3627 : word := B#(  0,  0);	//
	D_3628 : word := B#(  0,  0);	//
	D_3629 : int  := +00000;	//
	D_3630 : word := 2#0000000000000000;	//
	D_3631 : word := B#(  0,  0);	//
	D_3632 : word := B#(  1,  1);	// State (16)
	D_3633 : word := B#(  0,  1);	//
	D_3634 : word := B#(  15,  12);	//
	D_3635 : int  := +00000;	//
	D_3636 : word := 2#0000000000000000;	//
	D_3637 : word := B#(  0,  0);	//
	D_3638 : real := 0.000000000000;	//
	D_3639 : real := 145.000000000000;	//
	D_3640 : real := 0.000000000000;	//
	D_3641 : real := 0.725000000000;	//
	D_3642 : real := +0.0;	//
	D_3643 : int  := 00000;	//
	D_3644 : int  := 00000;	//
	D_3645 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_3646 : int  := 00000;	//
	D_3647 : int  := +00000;	//
	D_3648 : word  := B#(000,000);	//
	D_3649 : int  := +00000;	//
	D_3650 : real := 45.000000000000;	// Limit (1)
	D_3651 : real := +0.0;	//
	D_3652 : int  := +00000;	//
	D_3653 : word := 2#0000000000000000;	//
	D_3654 : int := +00000;	//
	D_3655 : word := B#(  2,  2);	//  010244 ( 02567 )
	D_3656 : word := 2#0000000000000100;	// MB TEMP ACEITE DE LUBRICACION
	D_3657 : real := +0.0;
	D_3658 : word := 2#0000000000000000;
	D_3659 : int  := +00000;
	D_3660 : int  := +00000;
	D_3661 : int  := +00000;
	D_3662 : word := B#(  0, 0);
	D_3663 : word := B#(000,000);
	D_3664 : word := 2#0000000000000000;
	D_3665 : int  := +00000;
	D_3666 : int  := +00000;
	D_3667 : word := B#(  1,  1);	// State (1)
	D_3668 : word := B#(  0,  1);	//
	D_3669 : word := B#(  5,  8);	//
	D_3670 : int  := +00000;	//
	D_3671 : word := 2#0000000000000000;	//
	D_3672 : word := B#(  0,  0);	//
	D_3673 : word := B#(  1,  1);	// State (2)
	D_3674 : word := B#(  0,  0);	//
	D_3675 : word := B#(  0,  0);	//
	D_3676 : int  := +00000;	//
	D_3677 : word := 2#0000000000000000;	//
	D_3678 : word := B#(  0,  0);	//
	D_3679 : word := B#(  1,  1);	// State (16)
	D_3680 : word := B#(  0,  1);	//
	D_3681 : word := B#(  15,  12);	//
	D_3682 : int  := +00000;	//
	D_3683 : word := 2#0000000000000000;	//
	D_3684 : word := B#(  0,  0);	//
	D_3685 : real := 0.000000000000;	//
	D_3686 : real := 300.000000000000;	//
	D_3687 : real := 0.000000000000;	//
	D_3688 : real := 1.500000000000;	//
	D_3689 : real := +0.0;	//
	D_3690 : int  := 00000;	//
	D_3691 : int  := 00000;	//
	D_3692 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_3693 : int  := 00000;	//
	D_3694 : int  := +00000;	//
	D_3695 : word  := B#(000,000);	//
	D_3696 : int  := +00000;	//
	D_3697 : real := 194.000000000000;	// Limit (1)
	D_3698 : real := +0.0;	//
	D_3699 : int  := +00000;	//
	D_3700 : word := 2#0000000000000000;	//
	D_3701 : int := +00000;	//
	D_3702 : word := B#(  2,  2);	//  010245 ( 02568 )
	D_3703 : word := 2#0000000000000100;	// MB TEMP DE AIRE ENT AL MULT
	D_3704 : real := +0.0;
	D_3705 : word := 2#0000000000000000;
	D_3706 : int  := +00001;
	D_3707 : int  := +00000;
	D_3708 : int  := +00000;
	D_3709 : word := B#(  0, 0);
	D_3710 : word := B#(000,000);
	D_3711 : word := 2#0000000000000000;
	D_3712 : int  := +00000;
	D_3713 : int  := +00000;
	D_3714 : word := B#(  1,  1);	// State (1)
	D_3715 : word := B#(  0,  1);	//
	D_3716 : word := B#(  5,  8);	//
	D_3717 : int  := +00201;	//
	D_3718 : word := 2#0000000000000000;	//
	D_3719 : word := B#(  0,  0);	//
	D_3720 : word := B#(  1,  1);	// State (2)
	D_3721 : word := B#(  0,  0);	//
	D_3722 : word := B#(  0,  0);	//
	D_3723 : int  := +00000;	//
	D_3724 : word := 2#0000000000000000;	//
	D_3725 : word := B#(  0,  0);	//
	D_3726 : word := B#(  1,  1);	// State (16)
	D_3727 : word := B#(  0,  1);	//
	D_3728 : word := B#(  15,  12);	//
	D_3729 : int  := +00000;	//
	D_3730 : word := 2#0000000000000000;	//
	D_3731 : word := B#(  0,  0);	//
	D_3732 : real := 0.000000000000;	//
	D_3733 : real := 300.000000000000;	//
	D_3734 : real := 0.000000000000;	//
	D_3735 : real := 1.500000000000;	//
	D_3736 : real := +0.0;	//
	D_3737 : int  := 00000;	//
	D_3738 : int  := 00000;	//
	D_3739 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_3740 : int  := 00000;	//
	D_3741 : int  := +00000;	//
	D_3742 : word  := B#(000,000);	//
	D_3743 : int  := +00000;	//
	D_3744 : real := 198.000000000000;	// Limit (1)
	D_3745 : real := +0.0;	//
	D_3746 : int  := +00000;	//
	D_3747 : word := 2#0000000000000000;	//
	D_3748 : int := +00000;	//
	D_3749 : word := B#(  2,  3);	//  010246 ( 02569 )
	D_3750 : word := 2#0000000000000100;	// MB TEMP CALENTADOR CAMISAS 1
	D_3751 : real := +0.0;
	D_3752 : word := 2#0000000000000000;
	D_3753 : int  := +00000;
	D_3754 : int  := +00000;
	D_3755 : int  := +00000;
	D_3756 : word := B#(  0, 0);
	D_3757 : word := B#(000,000);
	D_3758 : word := 2#0000000000000000;
	D_3759 : int  := +00000;
	D_3760 : int  := +00000;
	D_3761 : word := B#(  1,  1);	// State (1)
	D_3762 : word := B#(  0,  1);	//
	D_3763 : word := B#(  3,  4);	//
	D_3764 : int  := +00000;	//
	D_3765 : word := 2#0000000000000000;	//
	D_3766 : word := B#(  0,  0);	//
	D_3767 : word := B#(  1,  1);	// State (2)
	D_3768 : word := B#(  0,  1);	//
	D_3769 : word := B#(  1,  0);	//
	D_3770 : int  := +00000;	//
	D_3771 : word := 2#0000000000000000;	//
	D_3772 : word := B#(  0,  0);	//
	D_3773 : word := B#(  1,  1);	// State (3)
	D_3774 : word := B#(  0,  0);	//
	D_3775 : word := B#(  0,  0);	//
	D_3776 : int  := +00000;	//
	D_3777 : word := 2#0000000000000000;	//
	D_3778 : word := B#(  0,  0);	//
	D_3779 : word := B#(  1,  1);	// State (16)
	D_3780 : word := B#(  0,  1);	//
	D_3781 : word := B#(  15,  12);	//
	D_3782 : int  := +00000;	//
	D_3783 : word := 2#0000000000000000;	//
	D_3784 : word := B#(  0,  0);	//
	D_3785 : real := 0.000000000000;	//
	D_3786 : real := 300.000000000000;	//
	D_3787 : real := 0.000000000000;	//
	D_3788 : real := 1.500000000000;	//
	D_3789 : real := +0.0;	//
	D_3790 : int  := 00000;	//
	D_3791 : int  := 00000;	//
	D_3792 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_3793 : int  := 00000;	//
	D_3794 : int  := +00000;	//
	D_3795 : word  := B#(000,000);	//
	D_3796 : int  := +00000;	//
	D_3797 : real := 228.000000000000;	// Limit (1)
	D_3798 : real := +0.0;	//
	D_3799 : int  := +00000;	//
	D_3800 : word := 2#0000000000000000;	//
	D_3801 : int := +00000;	//
	D_3802 : real := 217.000000000000;	// Limit (2)
	D_3803 : real := +0.0;	//
	D_3804 : int  := +00000;	//
	D_3805 : word := 2#0000000000000000;	//
	D_3806 : int := +00000;	//
	D_3807 : word := B#(  2,  3);	//  010247 ( 02570 )
	D_3808 : word := 2#0000000000000100;	// MB TEMP CALENTADOR CAMISAS 2
	D_3809 : real := +0.0;
	D_3810 : word := 2#0000000000000000;
	D_3811 : int  := +00000;
	D_3812 : int  := +00000;
	D_3813 : int  := +00000;
	D_3814 : word := B#(  0, 0);
	D_3815 : word := B#(000,000);
	D_3816 : word := 2#0000000000000000;
	D_3817 : int  := +00000;
	D_3818 : int  := +00000;
	D_3819 : word := B#(  1,  1);	// State (1)
	D_3820 : word := B#(  0,  1);	//
	D_3821 : word := B#(  3,  4);	//
	D_3822 : int  := +00000;	//
	D_3823 : word := 2#0000000000000000;	//
	D_3824 : word := B#(  0,  0);	//
	D_3825 : word := B#(  1,  1);	// State (2)
	D_3826 : word := B#(  0,  1);	//
	D_3827 : word := B#(  1,  0);	//
	D_3828 : int  := +00000;	//
	D_3829 : word := 2#0000000000000000;	//
	D_3830 : word := B#(  0,  0);	//
	D_3831 : word := B#(  1,  1);	// State (3)
	D_3832 : word := B#(  0,  0);	//
	D_3833 : word := B#(  0,  0);	//
	D_3834 : int  := +00000;	//
	D_3835 : word := 2#0000000000000000;	//
	D_3836 : word := B#(  0,  0);	//
	D_3837 : word := B#(  1,  1);	// State (16)
	D_3838 : word := B#(  0,  1);	//
	D_3839 : word := B#(  15,  12);	//
	D_3840 : int  := +00000;	//
	D_3841 : word := 2#0000000000000000;	//
	D_3842 : word := B#(  0,  0);	//
	D_3843 : real := 0.000000000000;	//
	D_3844 : real := 300.000000000000;	//
	D_3845 : real := 0.000000000000;	//
	D_3846 : real := 1.500000000000;	//
	D_3847 : real := +0.0;	//
	D_3848 : int  := 00000;	//
	D_3849 : int  := 00000;	//
	D_3850 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_3851 : int  := 00000;	//
	D_3852 : int  := +00000;	//
	D_3853 : word  := B#(000,000);	//
	D_3854 : int  := +00000;	//
	D_3855 : real := 228.000000000000;	// Limit (1)
	D_3856 : real := +0.0;	//
	D_3857 : int  := +00000;	//
	D_3858 : word := 2#0000000000000000;	//
	D_3859 : int := +00000;	//
	D_3860 : real := 217.000000000000;	// Limit (2)
	D_3861 : real := +0.0;	//
	D_3862 : int  := +00000;	//
	D_3863 : word := 2#0000000000000000;	//
	D_3864 : int := +00000;	//
	D_3865 : word := B#(  2,  2);	//  010248 ( 02571 )
	D_3866 : word := 2#0000000000000100;	// MB TEMP AGUA DE ENTRADA AC/OC
	D_3867 : real := +0.0;
	D_3868 : word := 2#0000000000000000;
	D_3869 : int  := +00000;
	D_3870 : int  := +00000;
	D_3871 : int  := +00000;
	D_3872 : word := B#(  0, 0);
	D_3873 : word := B#(000,000);
	D_3874 : word := 2#0000000000000000;
	D_3875 : int  := +00000;
	D_3876 : int  := +00000;
	D_3877 : word := B#(  1,  1);	// State (1)
	D_3878 : word := B#(  0,  1);	//
	D_3879 : word := B#(  5,  8);	//
	D_3880 : int  := +00000;	//
	D_3881 : word := 2#0000000000000000;	//
	D_3882 : word := B#(  0,  0);	//
	D_3883 : word := B#(  1,  1);	// State (2)
	D_3884 : word := B#(  0,  0);	//
	D_3885 : word := B#(  0,  0);	//
	D_3886 : int  := +00000;	//
	D_3887 : word := 2#0000000000000000;	//
	D_3888 : word := B#(  0,  0);	//
	D_3889 : word := B#(  1,  1);	// State (16)
	D_3890 : word := B#(  0,  1);	//
	D_3891 : word := B#(  15,  12);	//
	D_3892 : int  := +00000;	//
	D_3893 : word := 2#0000000000000000;	//
	D_3894 : word := B#(  0,  0);	//
	D_3895 : real := 0.000000000000;	//
	D_3896 : real := 300.000000000000;	//
	D_3897 : real := 0.000000000000;	//
	D_3898 : real := 1.500000000000;	//
	D_3899 : real := +0.0;	//
	D_3900 : int  := 00000;	//
	D_3901 : int  := 00000;	//
	D_3902 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_3903 : int  := 00000;	//
	D_3904 : int  := +00000;	//
	D_3905 : word  := B#(000,000);	//
	D_3906 : int  := +00000;	//
	D_3907 : real := 140.000000000000;	// Limit (1)
	D_3908 : real := +0.0;	//
	D_3909 : int  := +00000;	//
	D_3910 : word := 2#0000000000000000;	//
	D_3911 : int := +00000;	//
	D_3912 : word := B#(  2,  3);	//  010249 ( 02572 )
	D_3913 : word := 2#0000000000000100;	// MB TEMP CUARTO DE MAQUINAS B2
	D_3914 : real := +0.0;
	D_3915 : word := 2#0000000000000000;
	D_3916 : int  := +00000;
	D_3917 : int  := +00000;
	D_3918 : int  := +00000;
	D_3919 : word := B#(  0, 0);
	D_3920 : word := B#(000,000);
	D_3921 : word := 2#0000000000000000;
	D_3922 : int  := +00000;
	D_3923 : int  := +00000;
	D_3924 : word := B#(  1,  1);	// State (1)
	D_3925 : word := B#(  0,  1);	//
	D_3926 : word := B#(  5,  8);	//
	D_3927 : int  := +00000;	//
	D_3928 : word := 2#0000000000000000;	//
	D_3929 : word := B#(  0,  0);	//
	D_3930 : word := B#(  1,  1);	// State (2)
	D_3931 : word := B#(  0,  1);	//
	D_3932 : word := B#(  3,  4);	//
	D_3933 : int  := +00000;	//
	D_3934 : word := 2#0000000000000000;	//
	D_3935 : word := B#(  0,  0);	//
	D_3936 : word := B#(  1,  1);	// State (3)
	D_3937 : word := B#(  0,  0);	//
	D_3938 : word := B#(  0,  0);	//
	D_3939 : int  := +00000;	//
	D_3940 : word := 2#0000000000000000;	//
	D_3941 : word := B#(  0,  0);	//
	D_3942 : word := B#(  1,  1);	// State (16)
	D_3943 : word := B#(  0,  1);	//
	D_3944 : word := B#(  15,  12);	//
	D_3945 : int  := +00000;	//
	D_3946 : word := 2#0000000000000000;	//
	D_3947 : word := B#(  0,  0);	//
	D_3948 : real := 32.000000000000;	//
	D_3949 : real := 212.000000000000;	//
	D_3950 : real := 0.900000000000;	//
	D_3951 : real := 0.900000000000;	//
	D_3952 : real := +0.0;	//
	D_3953 : int  := 00000;	//
	D_3954 : int  := 00000;	//
	D_3955 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_3956 : int  := 00000;	//
	D_3957 : int  := +00000;	//
	D_3958 : word  := B#(000,000);	//
	D_3959 : int  := +00000;	//
	D_3960 : real := 122.000000000000;	// Limit (1)
	D_3961 : real := +0.0;	//
	D_3962 : int  := +00000;	//
	D_3963 : word := 2#0000000000000000;	//
	D_3964 : int := +00000;	//
	D_3965 : real := 104.000000000000;	// Limit (2)
	D_3966 : real := +0.0;	//
	D_3967 : int  := +00000;	//
	D_3968 : word := 2#0000000000000000;	//
	D_3969 : int := +00000;	//
	D_3970 : word := B#(  2,  2);	//  010250 ( 02573 )
	D_3971 : word := 2#0000000000000100;	// MB VELOCIDAD DEL MOTOR RPM
	D_3972 : real := +0.0;
	D_3973 : word := 2#0000000000000000;
	D_3974 : int  := +00000;
	D_3975 : int  := +00000;
	D_3976 : int  := +00000;
	D_3977 : word := B#(  0, 0);
	D_3978 : word := B#(000,000);
	D_3979 : word := 2#0000000000000000;
	D_3980 : int  := +00000;
	D_3981 : int  := +00000;
	D_3982 : word := B#(  1,  1);	// State (1)
	D_3983 : word := B#(  0,  1);	//
	D_3984 : word := B#(  6,  0);	//
	D_3985 : int  := +00000;	//
	D_3986 : word := 2#0000000000000000;	//
	D_3987 : word := B#(  0,  0);	//
	D_3988 : word := B#(  1,  1);	// State (2)
	D_3989 : word := B#(  0,  0);	//
	D_3990 : word := B#(  0,  0);	//
	D_3991 : int  := +00000;	//
	D_3992 : word := 2#0000000000000000;	//
	D_3993 : word := B#(  0,  0);	//
	D_3994 : word := B#(  1,  1);	// State (16)
	D_3995 : word := B#(  0,  1);	//
	D_3996 : word := B#(  15,  12);	//
	D_3997 : int  := +00000;	//
	D_3998 : word := 2#0000000000000000;	//
	D_3999 : word := B#(  0,  0);	//
	D_4000 : real := 0.000000000000;	//
	D_4001 : real := 1500.000000000000;	//
	D_4002 : real := 15.000000000000;	//
	D_4003 : real := 15.000000000000;	//
	D_4004 : real := +0.0;	//
	D_4005 : int  := 00000;	//
	D_4006 : int  := 00000;	//
	D_4007 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_4008 : int  := 00000;	//
	D_4009 : int  := +00000;	//
	D_4010 : word  := B#(000,000);	//
	D_4011 : int  := +00000;	//
	D_4012 : real := 1100.000000000000;	// Limit (1)
	D_4013 : real := +0.0;	//
	D_4014 : int  := +00000;	//
	D_4015 : word := 2#0000000000000000;	//
	D_4016 : int := +00000;	//
	D_4017 : word := B#(  2,  3);	//  010251 ( 02574 )
	D_4018 : word := 2#0000000000000100;	// MB TEMP SALIDA GASES TURBO IZQ
	D_4019 : real := +0.0;
	D_4020 : word := 2#0000000000000000;
	D_4021 : int  := +00000;
	D_4022 : int  := +00000;
	D_4023 : int  := +00000;
	D_4024 : word := B#(  0, 0);
	D_4025 : word := B#(000,000);
	D_4026 : word := 2#0000000000000000;
	D_4027 : int  := +00000;
	D_4028 : int  := +00000;
	D_4029 : word := B#(  1,  1);	// State (1)
	D_4030 : word := B#(  0,  1);	//
	D_4031 : word := B#(  5,  8);	//
	D_4032 : int  := +00000;	//
	D_4033 : word := 2#0000000000000000;	//
	D_4034 : word := B#(  0,  0);	//
	D_4035 : word := B#(  1,  1);	// State (2)
	D_4036 : word := B#(  0,  1);	//
	D_4037 : word := B#(  3,  4);	//
	D_4038 : int  := +00000;	//
	D_4039 : word := 2#0000000000000000;	//
	D_4040 : word := B#(  0,  0);	//
	D_4041 : word := B#(  1,  1);	// State (3)
	D_4042 : word := B#(  0,  0);	//
	D_4043 : word := B#(  0,  0);	//
	D_4044 : int  := +00000;	//
	D_4045 : word := 2#0000000000000000;	//
	D_4046 : word := B#(  0,  0);	//
	D_4047 : word := B#(  1,  1);	// State (16)
	D_4048 : word := B#(  0,  1);	//
	D_4049 : word := B#(  15,  12);	//
	D_4050 : int  := +00000;	//
	D_4051 : word := 2#0000000000000000;	//
	D_4052 : word := B#(  0,  0);	//
	D_4053 : real := 0.000000000000;	//
	D_4054 : real := 1300.000000000000;	//
	D_4055 : real := 0.000000000000;	//
	D_4056 : real := 6.500000000000;	//
	D_4057 : real := +0.0;	//
	D_4058 : int  := 00000;	//
	D_4059 : int  := 00000;	//
	D_4060 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_4061 : int  := 00000;	//
	D_4062 : int  := +00000;	//
	D_4063 : word  := B#(000,000);	//
	D_4064 : int  := +00000;	//
	D_4065 : real := 1110.000000000000;	// Limit (1)
	D_4066 : real := +0.0;	//
	D_4067 : int  := +00000;	//
	D_4068 : word := 2#0000000000000000;	//
	D_4069 : int := +00000;	//
	D_4070 : real := 1020.000000000000;	// Limit (2)
	D_4071 : real := +0.0;	//
	D_4072 : int  := +00000;	//
	D_4073 : word := 2#0000000000000000;	//
	D_4074 : int := +00000;	//
	D_4075 : word := B#(  2,  3);	//  010252 ( 02575 )
	D_4076 : word := 2#0000000000000100;	// MB TEMP SALIDA GASES TURBO DER
	D_4077 : real := +0.0;
	D_4078 : word := 2#0000000000000000;
	D_4079 : int  := +00000;
	D_4080 : int  := +00000;
	D_4081 : int  := +00000;
	D_4082 : word := B#(  0, 0);
	D_4083 : word := B#(000,000);
	D_4084 : word := 2#0000000000000000;
	D_4085 : int  := +00000;
	D_4086 : int  := +00000;
	D_4087 : word := B#(  1,  1);	// State (1)
	D_4088 : word := B#(  0,  1);	//
	D_4089 : word := B#(  5,  8);	//
	D_4090 : int  := +00000;	//
	D_4091 : word := 2#0000000000000000;	//
	D_4092 : word := B#(  0,  0);	//
	D_4093 : word := B#(  1,  1);	// State (2)
	D_4094 : word := B#(  0,  1);	//
	D_4095 : word := B#(  3,  4);	//
	D_4096 : int  := +00000;	//
	D_4097 : word := 2#0000000000000000;	//
	D_4098 : word := B#(  0,  0);	//
	D_4099 : word := B#(  1,  1);	// State (3)
	D_4100 : word := B#(  0,  0);	//
	D_4101 : word := B#(  0,  0);	//
	D_4102 : int  := +00000;	//
	D_4103 : word := 2#0000000000000000;	//
	D_4104 : word := B#(  0,  0);	//
	D_4105 : word := B#(  1,  1);	// State (16)
	D_4106 : word := B#(  0,  1);	//
	D_4107 : word := B#(  15,  12);	//
	D_4108 : int  := +00000;	//
	D_4109 : word := 2#0000000000000000;	//
	D_4110 : word := B#(  0,  0);	//
	D_4111 : real := 0.000000000000;	//
	D_4112 : real := 1300.000000000000;	//
	D_4113 : real := 0.000000000000;	//
	D_4114 : real := 6.500000000000;	//
	D_4115 : real := +0.0;	//
	D_4116 : int  := 00000;	//
	D_4117 : int  := 00000;	//
	D_4118 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_4119 : int  := 00000;	//
	D_4120 : int  := +00000;	//
	D_4121 : word  := B#(000,000);	//
	D_4122 : int  := +00000;	//
	D_4123 : real := 1110.000000000000;	// Limit (1)
	D_4124 : real := +0.0;	//
	D_4125 : int  := +00000;	//
	D_4126 : word := 2#0000000000000000;	//
	D_4127 : int := +00000;	//
	D_4128 : real := 1020.000000000000;	// Limit (2)
	D_4129 : real := +0.0;	//
	D_4130 : int  := +00000;	//
	D_4131 : word := 2#0000000000000000;	//
	D_4132 : int := +00000;	//
	D_4133 : word := B#(  2,  2);	//  010253 ( 02576 )
	D_4134 : word := 2#0000000000000100;	// MB TEMP GASES ENT TURBO IZQ
	D_4135 : real := +0.0;
	D_4136 : word := 2#0000000000000000;
	D_4137 : int  := +00000;
	D_4138 : int  := +00000;
	D_4139 : int  := +00000;
	D_4140 : word := B#(  0, 0);
	D_4141 : word := B#(000,000);
	D_4142 : word := 2#0000000000000000;
	D_4143 : int  := +00000;
	D_4144 : int  := +00000;
	D_4145 : word := B#(  1,  1);	// State (1)
	D_4146 : word := B#(  0,  1);	//
	D_4147 : word := B#(  1,  0);	//
	D_4148 : int  := +00000;	//
	D_4149 : word := 2#0000000000000000;	//
	D_4150 : word := B#(  0,  0);	//
	D_4151 : word := B#(  1,  1);	// State (2)
	D_4152 : word := B#(  0,  0);	//
	D_4153 : word := B#(  0,  0);	//
	D_4154 : int  := +00000;	//
	D_4155 : word := 2#0000000000000000;	//
	D_4156 : word := B#(  0,  0);	//
	D_4157 : word := B#(  1,  1);	// State (16)
	D_4158 : word := B#(  0,  1);	//
	D_4159 : word := B#(  15,  12);	//
	D_4160 : int  := +00000;	//
	D_4161 : word := 2#0000000000000000;	//
	D_4162 : word := B#(  0,  0);	//
	D_4163 : real := 0.000000000000;	//
	D_4164 : real := 1500.000000000000;	//
	D_4165 : real := 0.000000000000;	//
	D_4166 : real := 7.500000000000;	//
	D_4167 : real := +0.0;	//
	D_4168 : int  := 00000;	//
	D_4169 : int  := 00000;	//
	D_4170 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_4171 : int  := 00000;	//
	D_4172 : int  := +00000;	//
	D_4173 : word  := B#(000,000);	//
	D_4174 : int  := +00000;	//
	D_4175 : real := 1166.000000000000;	// Limit (1)
	D_4176 : real := +0.0;	//
	D_4177 : int  := +00000;	//
	D_4178 : word := 2#0000000000000000;	//
	D_4179 : int := +00000;	//
	D_4180 : word := B#(  2,  2);	//  010254 ( 02577 )
	D_4181 : word := 2#0000000000000100;	// MB TEMP GASES ENT TURBO DER
	D_4182 : real := +0.0;
	D_4183 : word := 2#0000000000000000;
	D_4184 : int  := +00000;
	D_4185 : int  := +00000;
	D_4186 : int  := +00000;
	D_4187 : word := B#(  0, 0);
	D_4188 : word := B#(000,000);
	D_4189 : word := 2#0000000000000000;
	D_4190 : int  := +00000;
	D_4191 : int  := +00000;
	D_4192 : word := B#(  1,  1);	// State (1)
	D_4193 : word := B#(  0,  1);	//
	D_4194 : word := B#(  5,  8);	//
	D_4195 : int  := +00000;	//
	D_4196 : word := 2#0000000000000000;	//
	D_4197 : word := B#(  0,  0);	//
	D_4198 : word := B#(  1,  1);	// State (2)
	D_4199 : word := B#(  0,  0);	//
	D_4200 : word := B#(  0,  0);	//
	D_4201 : int  := +00000;	//
	D_4202 : word := 2#0000000000000000;	//
	D_4203 : word := B#(  0,  0);	//
	D_4204 : word := B#(  1,  1);	// State (16)
	D_4205 : word := B#(  0,  1);	//
	D_4206 : word := B#(  15,  12);	//
	D_4207 : int  := +00000;	//
	D_4208 : word := 2#0000000000000000;	//
	D_4209 : word := B#(  0,  0);	//
	D_4210 : real := 0.000000000000;	//
	D_4211 : real := 1500.000000000000;	//
	D_4212 : real := 0.000000000000;	//
	D_4213 : real := 7.500000000000;	//
	D_4214 : real := +0.0;	//
	D_4215 : int  := 00000;	//
	D_4216 : int  := 00000;	//
	D_4217 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_4218 : int  := 00000;	//
	D_4219 : int  := +00000;	//
	D_4220 : word  := B#(000,000);	//
	D_4221 : int  := +00000;	//
	D_4222 : real := 1166.000000000000;	// Limit (1)
	D_4223 : real := +0.0;	//
	D_4224 : int  := +00000;	//
	D_4225 : word := 2#0000000000000000;	//
	D_4226 : int := +00000;	//
	D_4227 : word := B#(  2,  3);	//  010255 ( 02578 )
	D_4228 : word := 2#0000000000000100;	// MB TEMP CILINDRO 1
	D_4229 : real := +0.0;
	D_4230 : word := 2#0000000000000000;
	D_4231 : int  := +00001;
	D_4232 : int  := +00000;
	D_4233 : int  := +00000;
	D_4234 : word := B#(  0, 0);
	D_4235 : word := B#(000,000);
	D_4236 : word := 2#0000000000000000;
	D_4237 : int  := +00000;
	D_4238 : int  := +00000;
	D_4239 : word := B#(  1,  1);	// State (1)
	D_4240 : word := B#(  0,  1);	//
	D_4241 : word := B#(  5,  8);	//
	D_4242 : int  := +00200;	//
	D_4243 : word := 2#0000000000000000;	//
	D_4244 : word := B#(  0,  0);	//
	D_4245 : word := B#(  1,  1);	// State (2)
	D_4246 : word := B#(  0,  1);	//
	D_4247 : word := B#(  3,  4);	//
	D_4248 : int  := +00000;	//
	D_4249 : word := 2#0000000000000000;	//
	D_4250 : word := B#(  0,  0);	//
	D_4251 : word := B#(  1,  1);	// State (3)
	D_4252 : word := B#(  0,  0);	//
	D_4253 : word := B#(  0,  0);	//
	D_4254 : int  := +00000;	//
	D_4255 : word := 2#0000000000000000;	//
	D_4256 : word := B#(  0,  0);	//
	D_4257 : word := B#(  1,  1);	// State (16)
	D_4258 : word := B#(  0,  1);	//
	D_4259 : word := B#(  15,  12);	//
	D_4260 : int  := +00000;	//
	D_4261 : word := 2#0000000000000000;	//
	D_4262 : word := B#(  0,  0);	//
	D_4263 : real := 0.000000000000;	//
	D_4264 : real := 1300.000000000000;	//
	D_4265 : real := 0.000000000000;	//
	D_4266 : real := 0.000000000000;	//
	D_4267 : real := +0.0;	//
	D_4268 : int  := 00000;	//
	D_4269 : int  := 00000;	//
	D_4270 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_4271 : int  := 00000;	//
	D_4272 : int  := +00000;	//
	D_4273 : word  := B#(000,000);	//
	D_4274 : int  := +00000;	//
	D_4275 : real := 1110.000000000000;	// Limit (1)
	D_4276 : real := +0.0;	//
	D_4277 : int  := +00000;	//
	D_4278 : word := 2#0000000000000000;	//
	D_4279 : int := +00000;	//
	D_4280 : real := 1022.000000000000;	// Limit (2)
	D_4281 : real := +0.0;	//
	D_4282 : int  := +00000;	//
	D_4283 : word := 2#0000000000000000;	//
	D_4284 : int := +00000;	//
	D_4285 : word := B#(  2,  3);	//  010255D ( 02579 )
	D_4286 : word := 2#0000000000000100;	// MB CILINDRO TEMP 1 DESV.
	D_4287 : real := +0.0;
	D_4288 : word := 2#0000000000000000;
	D_4289 : int  := +00001;
	D_4290 : int  := +00000;
	D_4291 : int  := +00000;
	D_4292 : word := B#(  0, 0);
	D_4293 : word := B#(000,000);
	D_4294 : word := 2#0000000000000000;
	D_4295 : int  := +00000;
	D_4296 : int  := +00000;
	D_4297 : word := B#(  1,  1);	// State (1)
	D_4298 : word := B#(  0,  1);	//
	D_4299 : word := B#(  5,  8);	//
	D_4300 : int  := +00200;	//
	D_4301 : word := 2#0000000000000000;	//
	D_4302 : word := B#(  0,  0);	//
	D_4303 : word := B#(  1,  1);	// State (2)
	D_4304 : word := B#(  0,  0);	//
	D_4305 : word := B#(  0,  0);	//
	D_4306 : int  := +00000;	//
	D_4307 : word := 2#0000000000000000;	//
	D_4308 : word := B#(  0,  0);	//
	D_4309 : word := B#(  1,  1);	// State (3)
	D_4310 : word := B#(  0,  1);	//
	D_4311 : word := B#(  6,  1);	//
	D_4312 : int  := +00000;	//
	D_4313 : word := 2#0000000000000000;	//
	D_4314 : word := B#(  0,  0);	//
	D_4315 : word := B#(  1,  1);	// State (16)
	D_4316 : word := B#(  0,  1);	//
	D_4317 : word := B#(  15,  12);	//
	D_4318 : int  := +00000;	//
	D_4319 : word := 2#0000000000000000;	//
	D_4320 : word := B#(  0,  0);	//
	D_4321 : real := -150.000000000000;	//
	D_4322 : real := 150.000000000000;	//
	D_4323 : real := 0.000000000000;	//
	D_4324 : real := 1.500000000000;	//
	D_4325 : real := +0.0;	//
	D_4326 : int  := 00000;	//
	D_4327 : int  := 00000;	//
	D_4328 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_4329 : int  := 00000;	//
	D_4330 : int  := +00000;	//
	D_4331 : word  := B#(000,000);	//
	D_4332 : int  := +00000;	//
	D_4333 : real := 120.000000000000;	// Limit (1)
	D_4334 : real := +0.0;	//
	D_4335 : int  := +00000;	//
	D_4336 : word := 2#0000000000000000;	//
	D_4337 : int := +00000;	//
	D_4338 : real := -120.000000000000;	// Limit (2)
	D_4339 : real := +0.0;	//
	D_4340 : int  := +00000;	//
	D_4341 : word := 2#0000000000000000;	//
	D_4342 : int := +00000;	//
	D_4343 : word := B#(  2,  3);	//  010256 ( 02580 )
	D_4344 : word := 2#0000000000000100;	// MB TEMP CILINDRO 2
	D_4345 : real := +0.0;
	D_4346 : word := 2#0000000000000000;
	D_4347 : int  := +00001;
	D_4348 : int  := +00000;
	D_4349 : int  := +00000;
	D_4350 : word := B#(  0, 0);
	D_4351 : word := B#(000,000);
	D_4352 : word := 2#0000000000000000;
	D_4353 : int  := +00000;
	D_4354 : int  := +00000;
	D_4355 : word := B#(  1,  1);	// State (1)
	D_4356 : word := B#(  0,  1);	//
	D_4357 : word := B#(  5,  8);	//
	D_4358 : int  := +00200;	//
	D_4359 : word := 2#0000000000000000;	//
	D_4360 : word := B#(  0,  0);	//
	D_4361 : word := B#(  1,  1);	// State (2)
	D_4362 : word := B#(  0,  1);	//
	D_4363 : word := B#(  3,  4);	//
	D_4364 : int  := +00000;	//
	D_4365 : word := 2#0000000000000000;	//
	D_4366 : word := B#(  0,  0);	//
	D_4367 : word := B#(  1,  1);	// State (3)
	D_4368 : word := B#(  0,  0);	//
	D_4369 : word := B#(  0,  0);	//
	D_4370 : int  := +00000;	//
	D_4371 : word := 2#0000000000000000;	//
	D_4372 : word := B#(  0,  0);	//
	D_4373 : word := B#(  1,  1);	// State (16)
	D_4374 : word := B#(  0,  1);	//
	D_4375 : word := B#(  15,  12);	//
	D_4376 : int  := +00000;	//
	D_4377 : word := 2#0000000000000000;	//
	D_4378 : word := B#(  0,  0);	//
	D_4379 : real := 0.000000000000;	//
	D_4380 : real := 1300.000000000000;	//
	D_4381 : real := 0.000000000000;	//
	D_4382 : real := 0.000000000000;	//
	D_4383 : real := +0.0;	//
	D_4384 : int  := 00000;	//
	D_4385 : int  := 00000;	//
	D_4386 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_4387 : int  := 00000;	//
	D_4388 : int  := +00000;	//
	D_4389 : word  := B#(000,000);	//
	D_4390 : int  := +00000;	//
	D_4391 : real := 1110.000000000000;	// Limit (1)
	D_4392 : real := +0.0;	//
	D_4393 : int  := +00000;	//
	D_4394 : word := 2#0000000000000000;	//
	D_4395 : int := +00000;	//
	D_4396 : real := 1022.000000000000;	// Limit (2)
	D_4397 : real := +0.0;	//
	D_4398 : int  := +00000;	//
	D_4399 : word := 2#0000000000000000;	//
	D_4400 : int := +00000;	//
	D_4401 : word := B#(  2,  3);	//  010256D ( 02581 )
	D_4402 : word := 2#0000000000000100;	// MB CILINDRO TEMP 2 DESV.
	D_4403 : real := +0.0;
	D_4404 : word := 2#0000000000000000;
	D_4405 : int  := +00001;
	D_4406 : int  := +00000;
	D_4407 : int  := +00000;
	D_4408 : word := B#(  0, 0);
	D_4409 : word := B#(000,000);
	D_4410 : word := 2#0000000000000000;
	D_4411 : int  := +00000;
	D_4412 : int  := +00000;
	D_4413 : word := B#(  1,  1);	// State (1)
	D_4414 : word := B#(  0,  1);	//
	D_4415 : word := B#(  5,  8);	//
	D_4416 : int  := +00200;	//
	D_4417 : word := 2#0000000000000000;	//
	D_4418 : word := B#(  0,  0);	//
	D_4419 : word := B#(  1,  1);	// State (2)
	D_4420 : word := B#(  0,  0);	//
	D_4421 : word := B#(  0,  0);	//
	D_4422 : int  := +00000;	//
	D_4423 : word := 2#0000000000000000;	//
	D_4424 : word := B#(  0,  0);	//
	D_4425 : word := B#(  1,  1);	// State (3)
	D_4426 : word := B#(  0,  1);	//
	D_4427 : word := B#(  6,  1);	//
	D_4428 : int  := +00000;	//
	D_4429 : word := 2#0000000000000000;	//
	D_4430 : word := B#(  0,  0);	//
	D_4431 : word := B#(  1,  1);	// State (16)
	D_4432 : word := B#(  0,  1);	//
	D_4433 : word := B#(  15,  12);	//
	D_4434 : int  := +00000;	//
	D_4435 : word := 2#0000000000000000;	//
	D_4436 : word := B#(  0,  0);	//
	D_4437 : real := -150.000000000000;	//
	D_4438 : real := 150.000000000000;	//
	D_4439 : real := 0.000000000000;	//
	D_4440 : real := 1.500000000000;	//
	D_4441 : real := +0.0;	//
	D_4442 : int  := 00000;	//
	D_4443 : int  := 00000;	//
	D_4444 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_4445 : int  := 00000;	//
	D_4446 : int  := +00000;	//
	D_4447 : word  := B#(000,000);	//
	D_4448 : int  := +00000;	//
	D_4449 : real := 120.000000000000;	// Limit (1)
	D_4450 : real := +0.0;	//
	D_4451 : int  := +00000;	//
	D_4452 : word := 2#0000000000000000;	//
	D_4453 : int := +00000;	//
	D_4454 : real := -120.000000000000;	// Limit (2)
	D_4455 : real := +0.0;	//
	D_4456 : int  := +00000;	//
	D_4457 : word := 2#0000000000000000;	//
	D_4458 : int := +00000;	//
	D_4459 : word := B#(  2,  3);	//  010257 ( 02582 )
	D_4460 : word := 2#0000000000000100;	// MB TEMP CILINDRO 3
	D_4461 : real := +0.0;
	D_4462 : word := 2#0000000000000000;
	D_4463 : int  := +00001;
	D_4464 : int  := +00000;
	D_4465 : int  := +00000;
	D_4466 : word := B#(  0, 0);
	D_4467 : word := B#(000,000);
	D_4468 : word := 2#0000000000000000;
	D_4469 : int  := +00000;
	D_4470 : int  := +00000;
	D_4471 : word := B#(  1,  1);	// State (1)
	D_4472 : word := B#(  0,  1);	//
	D_4473 : word := B#(  5,  8);	//
	D_4474 : int  := +00200;	//
	D_4475 : word := 2#0000000000000000;	//
	D_4476 : word := B#(  0,  0);	//
	D_4477 : word := B#(  1,  1);	// State (2)
	D_4478 : word := B#(  0,  1);	//
	D_4479 : word := B#(  3,  4);	//
	D_4480 : int  := +00000;	//
	D_4481 : word := 2#0000000000000000;	//
	D_4482 : word := B#(  0,  0);	//
	D_4483 : word := B#(  1,  1);	// State (3)
	D_4484 : word := B#(  0,  0);	//
	D_4485 : word := B#(  0,  0);	//
	D_4486 : int  := +00000;	//
	D_4487 : word := 2#0000000000000000;	//
	D_4488 : word := B#(  0,  0);	//
	D_4489 : word := B#(  1,  1);	// State (16)
	D_4490 : word := B#(  0,  1);	//
	D_4491 : word := B#(  15,  12);	//
	D_4492 : int  := +00000;	//
	D_4493 : word := 2#0000000000000000;	//
	D_4494 : word := B#(  0,  0);	//
	D_4495 : real := 0.000000000000;	//
	D_4496 : real := 1300.000000000000;	//
	D_4497 : real := 0.000000000000;	//
	D_4498 : real := 0.000000000000;	//
	D_4499 : real := +0.0;	//
	D_4500 : int  := 00000;	//
	D_4501 : int  := 00000;	//
	D_4502 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_4503 : int  := 00000;	//
	D_4504 : int  := +00000;	//
	D_4505 : word  := B#(000,000);	//
	D_4506 : int  := +00000;	//
	D_4507 : real := 1110.000000000000;	// Limit (1)
	D_4508 : real := +0.0;	//
	D_4509 : int  := +00000;	//
	D_4510 : word := 2#0000000000000000;	//
	D_4511 : int := +00000;	//
	D_4512 : real := 1022.000000000000;	// Limit (2)
	D_4513 : real := +0.0;	//
	D_4514 : int  := +00000;	//
	D_4515 : word := 2#0000000000000000;	//
	D_4516 : int := +00000;	//
	D_4517 : word := B#(  2,  3);	//  010257D ( 02583 )
	D_4518 : word := 2#0000000000000100;	// MB CILINDRO TEMP 3 DESV.
	D_4519 : real := +0.0;
	D_4520 : word := 2#0000000000000000;
	D_4521 : int  := +00001;
	D_4522 : int  := +00000;
	D_4523 : int  := +00000;
	D_4524 : word := B#(  0, 0);
	D_4525 : word := B#(000,000);
	D_4526 : word := 2#0000000000000000;
	D_4527 : int  := +00000;
	D_4528 : int  := +00000;
	D_4529 : word := B#(  1,  1);	// State (1)
	D_4530 : word := B#(  0,  1);	//
	D_4531 : word := B#(  5,  8);	//
	D_4532 : int  := +00200;	//
	D_4533 : word := 2#0000000000000000;	//
	D_4534 : word := B#(  0,  0);	//
	D_4535 : word := B#(  1,  1);	// State (2)
	D_4536 : word := B#(  0,  0);	//
	D_4537 : word := B#(  0,  0);	//
	D_4538 : int  := +00000;	//
	D_4539 : word := 2#0000000000000000;	//
	D_4540 : word := B#(  0,  0);	//
	D_4541 : word := B#(  1,  1);	// State (3)
	D_4542 : word := B#(  0,  1);	//
	D_4543 : word := B#(  6,  1);	//
	D_4544 : int  := +00000;	//
	D_4545 : word := 2#0000000000000000;	//
	D_4546 : word := B#(  0,  0);	//
	D_4547 : word := B#(  1,  1);	// State (16)
	D_4548 : word := B#(  0,  1);	//
	D_4549 : word := B#(  15,  12);	//
	D_4550 : int  := +00000;	//
	D_4551 : word := 2#0000000000000000;	//
	D_4552 : word := B#(  0,  0);	//
	D_4553 : real := -150.000000000000;	//
	D_4554 : real := 150.000000000000;	//
	D_4555 : real := 0.000000000000;	//
	D_4556 : real := 1.500000000000;	//
	D_4557 : real := +0.0;	//
	D_4558 : int  := 00000;	//
	D_4559 : int  := 00000;	//
	D_4560 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_4561 : int  := 00000;	//
	D_4562 : int  := +00000;	//
	D_4563 : word  := B#(000,000);	//
	D_4564 : int  := +00000;	//
	D_4565 : real := 120.000000000000;	// Limit (1)
	D_4566 : real := +0.0;	//
	D_4567 : int  := +00000;	//
	D_4568 : word := 2#0000000000000000;	//
	D_4569 : int := +00000;	//
	D_4570 : real := -120.000000000000;	// Limit (2)
	D_4571 : real := +0.0;	//
	D_4572 : int  := +00000;	//
	D_4573 : word := 2#0000000000000000;	//
	D_4574 : int := +00000;	//
	D_4575 : word := B#(  2,  3);	//  010258 ( 02584 )
	D_4576 : word := 2#0000000000000100;	// MB TEMP CILINDRO 4
	D_4577 : real := +0.0;
	D_4578 : word := 2#0000000000000000;
	D_4579 : int  := +00001;
	D_4580 : int  := +00000;
	D_4581 : int  := +00000;
	D_4582 : word := B#(  0, 0);
	D_4583 : word := B#(000,000);
	D_4584 : word := 2#0000000000000000;
	D_4585 : int  := +00000;
	D_4586 : int  := +00000;
	D_4587 : word := B#(  1,  1);	// State (1)
	D_4588 : word := B#(  0,  1);	//
	D_4589 : word := B#(  5,  8);	//
	D_4590 : int  := +00200;	//
	D_4591 : word := 2#0000000000000000;	//
	D_4592 : word := B#(  0,  0);	//
	D_4593 : word := B#(  1,  1);	// State (2)
	D_4594 : word := B#(  0,  1);	//
	D_4595 : word := B#(  3,  4);	//
	D_4596 : int  := +00000;	//
	D_4597 : word := 2#0000000000000000;	//
	D_4598 : word := B#(  0,  0);	//
	D_4599 : word := B#(  1,  1);	// State (3)
	D_4600 : word := B#(  0,  0);	//
	D_4601 : word := B#(  0,  0);	//
	D_4602 : int  := +00000;	//
	D_4603 : word := 2#0000000000000000;	//
	D_4604 : word := B#(  0,  0);	//
	D_4605 : word := B#(  1,  1);	// State (16)
	D_4606 : word := B#(  0,  1);	//
	D_4607 : word := B#(  15,  12);	//
	D_4608 : int  := +00000;	//
	D_4609 : word := 2#0000000000000000;	//
	D_4610 : word := B#(  0,  0);	//
	D_4611 : real := 0.000000000000;	//
	D_4612 : real := 1300.000000000000;	//
	D_4613 : real := 0.000000000000;	//
	D_4614 : real := 0.000000000000;	//
	D_4615 : real := +0.0;	//
	D_4616 : int  := 00000;	//
	D_4617 : int  := 00000;	//
	D_4618 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_4619 : int  := 00000;	//
	D_4620 : int  := +00000;	//
	D_4621 : word  := B#(000,000);	//
	D_4622 : int  := +00000;	//
	D_4623 : real := 1110.000000000000;	// Limit (1)
	D_4624 : real := +0.0;	//
	D_4625 : int  := +00000;	//
	D_4626 : word := 2#0000000000000000;	//
	D_4627 : int := +00000;	//
	D_4628 : real := 1022.000000000000;	// Limit (2)
	D_4629 : real := +0.0;	//
	D_4630 : int  := +00000;	//
	D_4631 : word := 2#0000000000000000;	//
	D_4632 : int := +00000;	//
	D_4633 : word := B#(  2,  3);	//  010258D ( 02585 )
	D_4634 : word := 2#0000000000000100;	// MB  CILINDRO TEMP 4 DESV.
	D_4635 : real := +0.0;
	D_4636 : word := 2#0000000000000000;
	D_4637 : int  := +00001;
	D_4638 : int  := +00000;
	D_4639 : int  := +00000;
	D_4640 : word := B#(  0, 0);
	D_4641 : word := B#(000,000);
	D_4642 : word := 2#0000000000000000;
	D_4643 : int  := +00000;
	D_4644 : int  := +00000;
	D_4645 : word := B#(  1,  1);	// State (1)
	D_4646 : word := B#(  0,  1);	//
	D_4647 : word := B#(  5,  8);	//
	D_4648 : int  := +00200;	//
	D_4649 : word := 2#0000000000000000;	//
	D_4650 : word := B#(  0,  0);	//
	D_4651 : word := B#(  1,  1);	// State (2)
	D_4652 : word := B#(  0,  0);	//
	D_4653 : word := B#(  0,  0);	//
	D_4654 : int  := +00000;	//
	D_4655 : word := 2#0000000000000000;	//
	D_4656 : word := B#(  0,  0);	//
	D_4657 : word := B#(  1,  1);	// State (3)
	D_4658 : word := B#(  0,  1);	//
	D_4659 : word := B#(  6,  1);	//
	D_4660 : int  := +00000;	//
	D_4661 : word := 2#0000000000000000;	//
	D_4662 : word := B#(  0,  0);	//
	D_4663 : word := B#(  1,  1);	// State (16)
	D_4664 : word := B#(  0,  1);	//
	D_4665 : word := B#(  15,  12);	//
	D_4666 : int  := +00000;	//
	D_4667 : word := 2#0000000000000000;	//
	D_4668 : word := B#(  0,  0);	//
	D_4669 : real := -150.000000000000;	//
	D_4670 : real := 150.000000000000;	//
	D_4671 : real := 0.000000000000;	//
	D_4672 : real := 1.500000000000;	//
	D_4673 : real := +0.0;	//
	D_4674 : int  := 00000;	//
	D_4675 : int  := 00000;	//
	D_4676 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_4677 : int  := 00000;	//
	D_4678 : int  := +00000;	//
	D_4679 : word  := B#(000,000);	//
	D_4680 : int  := +00000;	//
	D_4681 : real := 120.000000000000;	// Limit (1)
	D_4682 : real := +0.0;	//
	D_4683 : int  := +00000;	//
	D_4684 : word := 2#0000000000000000;	//
	D_4685 : int := +00000;	//
	D_4686 : real := -120.000000000000;	// Limit (2)
	D_4687 : real := +0.0;	//
	D_4688 : int  := +00000;	//
	D_4689 : word := 2#0000000000000000;	//
	D_4690 : int := +00000;	//
	D_4691 : word := B#(  2,  3);	//  010259 ( 02586 )
	D_4692 : word := 2#0000000000000100;	// MB TEMP CILINDRO 5
	D_4693 : real := +0.0;
	D_4694 : word := 2#0000000000000000;
	D_4695 : int  := +00001;
	D_4696 : int  := +00000;
	D_4697 : int  := +00000;
	D_4698 : word := B#(  0, 0);
	D_4699 : word := B#(000,000);
	D_4700 : word := 2#0000000000000000;
	D_4701 : int  := +00000;
	D_4702 : int  := +00000;
	D_4703 : word := B#(  1,  1);	// State (1)
	D_4704 : word := B#(  0,  1);	//
	D_4705 : word := B#(  5,  8);	//
	D_4706 : int  := +00200;	//
	D_4707 : word := 2#0000000000000000;	//
	D_4708 : word := B#(  0,  0);	//
	D_4709 : word := B#(  1,  1);	// State (2)
	D_4710 : word := B#(  0,  1);	//
	D_4711 : word := B#(  3,  4);	//
	D_4712 : int  := +00000;	//
	D_4713 : word := 2#0000000000000000;	//
	D_4714 : word := B#(  0,  0);	//
	D_4715 : word := B#(  1,  1);	// State (3)
	D_4716 : word := B#(  0,  0);	//
	D_4717 : word := B#(  0,  0);	//
	D_4718 : int  := +00000;	//
	D_4719 : word := 2#0000000000000000;	//
	D_4720 : word := B#(  0,  0);	//
	D_4721 : word := B#(  1,  1);	// State (16)
	D_4722 : word := B#(  0,  1);	//
	D_4723 : word := B#(  15,  12);	//
	D_4724 : int  := +00000;	//
	D_4725 : word := 2#0000000000000000;	//
	D_4726 : word := B#(  0,  0);	//
	D_4727 : real := 0.000000000000;	//
	D_4728 : real := 1300.000000000000;	//
	D_4729 : real := 0.000000000000;	//
	D_4730 : real := 0.000000000000;	//
	D_4731 : real := +0.0;	//
	D_4732 : int  := 00000;	//
	D_4733 : int  := 00000;	//
	D_4734 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_4735 : int  := 00000;	//
	D_4736 : int  := +00000;	//
	D_4737 : word  := B#(000,000);	//
	D_4738 : int  := +00000;	//
	D_4739 : real := 1110.000000000000;	// Limit (1)
	D_4740 : real := +0.0;	//
	D_4741 : int  := +00000;	//
	D_4742 : word := 2#0000000000000000;	//
	D_4743 : int := +00000;	//
	D_4744 : real := 1022.000000000000;	// Limit (2)
	D_4745 : real := +0.0;	//
	D_4746 : int  := +00000;	//
	D_4747 : word := 2#0000000000000000;	//
	D_4748 : int := +00000;	//
	D_4749 : word := B#(  2,  3);	//  010259D ( 02587 )
	D_4750 : word := 2#0000000000000100;	// MB CILINDRO TEMP 5 DESV.
	D_4751 : real := +0.0;
	D_4752 : word := 2#0000000000000000;
	D_4753 : int  := +00001;
	D_4754 : int  := +00000;
	D_4755 : int  := +00000;
	D_4756 : word := B#(  0, 0);
	D_4757 : word := B#(000,000);
	D_4758 : word := 2#0000000000000000;
	D_4759 : int  := +00000;
	D_4760 : int  := +00000;
	D_4761 : word := B#(  1,  1);	// State (1)
	D_4762 : word := B#(  0,  1);	//
	D_4763 : word := B#(  5,  8);	//
	D_4764 : int  := +00200;	//
	D_4765 : word := 2#0000000000000000;	//
	D_4766 : word := B#(  0,  0);	//
	D_4767 : word := B#(  1,  1);	// State (2)
	D_4768 : word := B#(  0,  0);	//
	D_4769 : word := B#(  0,  0);	//
	D_4770 : int  := +00000;	//
	D_4771 : word := 2#0000000000000000;	//
	D_4772 : word := B#(  0,  0);	//
	D_4773 : word := B#(  1,  1);	// State (3)
	D_4774 : word := B#(  0,  1);	//
	D_4775 : word := B#(  6,  1);	//
	D_4776 : int  := +00000;	//
	D_4777 : word := 2#0000000000000000;	//
	D_4778 : word := B#(  0,  0);	//
	D_4779 : word := B#(  1,  1);	// State (16)
	D_4780 : word := B#(  0,  1);	//
	D_4781 : word := B#(  15,  12);	//
	D_4782 : int  := +00000;	//
	D_4783 : word := 2#0000000000000000;	//
	D_4784 : word := B#(  0,  0);	//
	D_4785 : real := -150.000000000000;	//
	D_4786 : real := 150.000000000000;	//
	D_4787 : real := 0.000000000000;	//
	D_4788 : real := 1.500000000000;	//
	D_4789 : real := +0.0;	//
	D_4790 : int  := 00000;	//
	D_4791 : int  := 00000;	//
	D_4792 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_4793 : int  := 00000;	//
	D_4794 : int  := +00000;	//
	D_4795 : word  := B#(000,000);	//
	D_4796 : int  := +00000;	//
	D_4797 : real := 120.000000000000;	// Limit (1)
	D_4798 : real := +0.0;	//
	D_4799 : int  := +00000;	//
	D_4800 : word := 2#0000000000000000;	//
	D_4801 : int := +00000;	//
	D_4802 : real := -120.000000000000;	// Limit (2)
	D_4803 : real := +0.0;	//
	D_4804 : int  := +00000;	//
	D_4805 : word := 2#0000000000000000;	//
	D_4806 : int := +00000;	//
	D_4807 : word := B#(  2,  3);	//  010260 ( 02588 )
	D_4808 : word := 2#0000000000000100;	// MB TEMP CILINDRO 6
	D_4809 : real := +0.0;
	D_4810 : word := 2#0000000000000000;
	D_4811 : int  := +00001;
	D_4812 : int  := +00000;
	D_4813 : int  := +00000;
	D_4814 : word := B#(  0, 0);
	D_4815 : word := B#(000,000);
	D_4816 : word := 2#0000000000000000;
	D_4817 : int  := +00000;
	D_4818 : int  := +00000;
	D_4819 : word := B#(  1,  1);	// State (1)
	D_4820 : word := B#(  0,  1);	//
	D_4821 : word := B#(  5,  8);	//
	D_4822 : int  := +00200;	//
	D_4823 : word := 2#0000000000000000;	//
	D_4824 : word := B#(  0,  0);	//
	D_4825 : word := B#(  1,  1);	// State (2)
	D_4826 : word := B#(  0,  1);	//
	D_4827 : word := B#(  3,  4);	//
	D_4828 : int  := +00000;	//
	D_4829 : word := 2#0000000000000000;	//
	D_4830 : word := B#(  0,  0);	//
	D_4831 : word := B#(  1,  1);	// State (3)
	D_4832 : word := B#(  0,  0);	//
	D_4833 : word := B#(  0,  0);	//
	D_4834 : int  := +00000;	//
	D_4835 : word := 2#0000000000000000;	//
	D_4836 : word := B#(  0,  0);	//
	D_4837 : word := B#(  1,  1);	// State (16)
	D_4838 : word := B#(  0,  1);	//
	D_4839 : word := B#(  15,  12);	//
	D_4840 : int  := +00000;	//
	D_4841 : word := 2#0000000000000000;	//
	D_4842 : word := B#(  0,  0);	//
	D_4843 : real := 0.000000000000;	//
	D_4844 : real := 1300.000000000000;	//
	D_4845 : real := 0.000000000000;	//
	D_4846 : real := 0.000000000000;	//
	D_4847 : real := +0.0;	//
	D_4848 : int  := 00000;	//
	D_4849 : int  := 00000;	//
	D_4850 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_4851 : int  := 00000;	//
	D_4852 : int  := +00000;	//
	D_4853 : word  := B#(000,000);	//
	D_4854 : int  := +00000;	//
	D_4855 : real := 1110.000000000000;	// Limit (1)
	D_4856 : real := +0.0;	//
	D_4857 : int  := +00000;	//
	D_4858 : word := 2#0000000000000000;	//
	D_4859 : int := +00000;	//
	D_4860 : real := 1022.000000000000;	// Limit (2)
	D_4861 : real := +0.0;	//
	D_4862 : int  := +00000;	//
	D_4863 : word := 2#0000000000000000;	//
	D_4864 : int := +00000;	//
	D_4865 : word := B#(  2,  3);	//  010260D ( 02589 )
	D_4866 : word := 2#0000000000000100;	// MB CILINDRO TEMP 6 DESV.
	D_4867 : real := +0.0;
	D_4868 : word := 2#0000000000000000;
	D_4869 : int  := +00001;
	D_4870 : int  := +00000;
	D_4871 : int  := +00000;
	D_4872 : word := B#(  0, 0);
	D_4873 : word := B#(000,000);
	D_4874 : word := 2#0000000000000000;
	D_4875 : int  := +00000;
	D_4876 : int  := +00000;
	D_4877 : word := B#(  1,  1);	// State (1)
	D_4878 : word := B#(  0,  1);	//
	D_4879 : word := B#(  5,  8);	//
	D_4880 : int  := +00200;	//
	D_4881 : word := 2#0000000000000000;	//
	D_4882 : word := B#(  0,  0);	//
	D_4883 : word := B#(  1,  1);	// State (2)
	D_4884 : word := B#(  0,  0);	//
	D_4885 : word := B#(  0,  0);	//
	D_4886 : int  := +00000;	//
	D_4887 : word := 2#0000000000000000;	//
	D_4888 : word := B#(  0,  0);	//
	D_4889 : word := B#(  1,  1);	// State (3)
	D_4890 : word := B#(  0,  1);	//
	D_4891 : word := B#(  6,  1);	//
	D_4892 : int  := +00000;	//
	D_4893 : word := 2#0000000000000000;	//
	D_4894 : word := B#(  0,  0);	//
	D_4895 : word := B#(  1,  1);	// State (16)
	D_4896 : word := B#(  0,  1);	//
	D_4897 : word := B#(  15,  12);	//
	D_4898 : int  := +00000;	//
	D_4899 : word := 2#0000000000000000;	//
	D_4900 : word := B#(  0,  0);	//
	D_4901 : real := -150.000000000000;	//
	D_4902 : real := 150.000000000000;	//
	D_4903 : real := 0.000000000000;	//
	D_4904 : real := 1.500000000000;	//
	D_4905 : real := +0.0;	//
	D_4906 : int  := 00000;	//
	D_4907 : int  := 00000;	//
	D_4908 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_4909 : int  := 00000;	//
	D_4910 : int  := +00000;	//
	D_4911 : word  := B#(000,000);	//
	D_4912 : int  := +00000;	//
	D_4913 : real := 120.000000000000;	// Limit (1)
	D_4914 : real := +0.0;	//
	D_4915 : int  := +00000;	//
	D_4916 : word := 2#0000000000000000;	//
	D_4917 : int := +00000;	//
	D_4918 : real := -120.000000000000;	// Limit (2)
	D_4919 : real := +0.0;	//
	D_4920 : int  := +00000;	//
	D_4921 : word := 2#0000000000000000;	//
	D_4922 : int := +00000;	//
	D_4923 : word := B#(  2,  3);	//  010261 ( 02590 )
	D_4924 : word := 2#0000000000000100;	// MB TEMP CILINDRO 7
	D_4925 : real := +0.0;
	D_4926 : word := 2#0000000000000000;
	D_4927 : int  := +00001;
	D_4928 : int  := +00000;
	D_4929 : int  := +00000;
	D_4930 : word := B#(  0, 0);
	D_4931 : word := B#(000,000);
	D_4932 : word := 2#0000000000000000;
	D_4933 : int  := +00000;
	D_4934 : int  := +00000;
	D_4935 : word := B#(  1,  1);	// State (1)
	D_4936 : word := B#(  0,  1);	//
	D_4937 : word := B#(  5,  8);	//
	D_4938 : int  := +00200;	//
	D_4939 : word := 2#0000000000000000;	//
	D_4940 : word := B#(  0,  0);	//
	D_4941 : word := B#(  1,  1);	// State (2)
	D_4942 : word := B#(  0,  1);	//
	D_4943 : word := B#(  3,  4);	//
	D_4944 : int  := +00000;	//
	D_4945 : word := 2#0000000000000000;	//
	D_4946 : word := B#(  0,  0);	//
	D_4947 : word := B#(  1,  1);	// State (3)
	D_4948 : word := B#(  0,  0);	//
	D_4949 : word := B#(  0,  0);	//
	D_4950 : int  := +00000;	//
	D_4951 : word := 2#0000000000000000;	//
	D_4952 : word := B#(  0,  0);	//
	D_4953 : word := B#(  1,  1);	// State (16)
	D_4954 : word := B#(  0,  1);	//
	D_4955 : word := B#(  15,  12);	//
	D_4956 : int  := +00000;	//
	D_4957 : word := 2#0000000000000000;	//
	D_4958 : word := B#(  0,  0);	//
	D_4959 : real := 0.000000000000;	//
	D_4960 : real := 1300.000000000000;	//
	D_4961 : real := 0.000000000000;	//
	D_4962 : real := 0.000000000000;	//
	D_4963 : real := +0.0;	//
	D_4964 : int  := 00000;	//
	D_4965 : int  := 00000;	//
	D_4966 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_4967 : int  := 00000;	//
	D_4968 : int  := +00000;	//
	D_4969 : word  := B#(000,000);	//
	D_4970 : int  := +00000;	//
	D_4971 : real := 1110.000000000000;	// Limit (1)
	D_4972 : real := +0.0;	//
	D_4973 : int  := +00000;	//
	D_4974 : word := 2#0000000000000000;	//
	D_4975 : int := +00000;	//
	D_4976 : real := 1022.000000000000;	// Limit (2)
	D_4977 : real := +0.0;	//
	D_4978 : int  := +00000;	//
	D_4979 : word := 2#0000000000000000;	//
	D_4980 : int := +00000;	//
	D_4981 : word := B#(  2,  3);	//  010261D ( 02591 )
	D_4982 : word := 2#0000000000000100;	// MB CILINDRO TEMP 7 DESV.
	D_4983 : real := +0.0;
	D_4984 : word := 2#0000000000000000;
	D_4985 : int  := +00001;
	D_4986 : int  := +00000;
	D_4987 : int  := +00000;
	D_4988 : word := B#(  0, 0);
	D_4989 : word := B#(000,000);
	D_4990 : word := 2#0000000000000000;
	D_4991 : int  := +00000;
	D_4992 : int  := +00000;
	D_4993 : word := B#(  1,  1);	// State (1)
	D_4994 : word := B#(  0,  1);	//
	D_4995 : word := B#(  5,  8);	//
	D_4996 : int  := +00200;	//
	D_4997 : word := 2#0000000000000000;	//
	D_4998 : word := B#(  0,  0);	//
	D_4999 : word := B#(  1,  1);	// State (2)
	D_5000 : word := B#(  0,  0);	//
	D_5001 : word := B#(  0,  0);	//
	D_5002 : int  := +00000;	//
	D_5003 : word := 2#0000000000000000;	//
	D_5004 : word := B#(  0,  0);	//
	D_5005 : word := B#(  1,  1);	// State (3)
	D_5006 : word := B#(  0,  1);	//
	D_5007 : word := B#(  6,  1);	//
	D_5008 : int  := +00000;	//
	D_5009 : word := 2#0000000000000000;	//
	D_5010 : word := B#(  0,  0);	//
	D_5011 : word := B#(  1,  1);	// State (16)
	D_5012 : word := B#(  0,  1);	//
	D_5013 : word := B#(  15,  12);	//
	D_5014 : int  := +00000;	//
	D_5015 : word := 2#0000000000000000;	//
	D_5016 : word := B#(  0,  0);	//
	D_5017 : real := -150.000000000000;	//
	D_5018 : real := 150.000000000000;	//
	D_5019 : real := 0.000000000000;	//
	D_5020 : real := 1.500000000000;	//
	D_5021 : real := +0.0;	//
	D_5022 : int  := 00000;	//
	D_5023 : int  := 00000;	//
	D_5024 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_5025 : int  := 00000;	//
	D_5026 : int  := +00000;	//
	D_5027 : word  := B#(000,000);	//
	D_5028 : int  := +00000;	//
	D_5029 : real := 120.000000000000;	// Limit (1)
	D_5030 : real := +0.0;	//
	D_5031 : int  := +00000;	//
	D_5032 : word := 2#0000000000000000;	//
	D_5033 : int := +00000;	//
	D_5034 : real := -120.000000000000;	// Limit (2)
	D_5035 : real := +0.0;	//
	D_5036 : int  := +00000;	//
	D_5037 : word := 2#0000000000000000;	//
	D_5038 : int := +00000;	//
	D_5039 : word := B#(  2,  3);	//  010262 ( 02592 )
	D_5040 : word := 2#0000000000000100;	// MB TEMP CILINDRO 8
	D_5041 : real := +0.0;
	D_5042 : word := 2#0000000000000000;
	D_5043 : int  := +00001;
	D_5044 : int  := +00000;
	D_5045 : int  := +00000;
	D_5046 : word := B#(  0, 0);
	D_5047 : word := B#(000,000);
	D_5048 : word := 2#0000000000000000;
	D_5049 : int  := +00000;
	D_5050 : int  := +00000;
	D_5051 : word := B#(  1,  1);	// State (1)
	D_5052 : word := B#(  0,  1);	//
	D_5053 : word := B#(  5,  8);	//
	D_5054 : int  := +00200;	//
	D_5055 : word := 2#0000000000000000;	//
	D_5056 : word := B#(  0,  0);	//
	D_5057 : word := B#(  1,  1);	// State (2)
	D_5058 : word := B#(  0,  1);	//
	D_5059 : word := B#(  3,  4);	//
	D_5060 : int  := +00000;	//
	D_5061 : word := 2#0000000000000000;	//
	D_5062 : word := B#(  0,  0);	//
	D_5063 : word := B#(  1,  1);	// State (3)
	D_5064 : word := B#(  0,  0);	//
	D_5065 : word := B#(  0,  0);	//
	D_5066 : int  := +00000;	//
	D_5067 : word := 2#0000000000000000;	//
	D_5068 : word := B#(  0,  0);	//
	D_5069 : word := B#(  1,  1);	// State (16)
	D_5070 : word := B#(  0,  1);	//
	D_5071 : word := B#(  15,  12);	//
	D_5072 : int  := +00000;	//
	D_5073 : word := 2#0000000000000000;	//
	D_5074 : word := B#(  0,  0);	//
	D_5075 : real := 0.000000000000;	//
	D_5076 : real := 1300.000000000000;	//
	D_5077 : real := 0.000000000000;	//
	D_5078 : real := 0.000000000000;	//
	D_5079 : real := +0.0;	//
	D_5080 : int  := 00000;	//
	D_5081 : int  := 00000;	//
	D_5082 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_5083 : int  := 00000;	//
	D_5084 : int  := +00000;	//
	D_5085 : word  := B#(000,000);	//
	D_5086 : int  := +00000;	//
	D_5087 : real := 1110.000000000000;	// Limit (1)
	D_5088 : real := +0.0;	//
	D_5089 : int  := +00000;	//
	D_5090 : word := 2#0000000000000000;	//
	D_5091 : int := +00000;	//
	D_5092 : real := 1022.000000000000;	// Limit (2)
	D_5093 : real := +0.0;	//
	D_5094 : int  := +00000;	//
	D_5095 : word := 2#0000000000000000;	//
	D_5096 : int := +00000;	//
	D_5097 : word := B#(  2,  3);	//  010262D ( 02593 )
	D_5098 : word := 2#0000000000000100;	// MB  CILINDRO TEMP 8 DESV.
	D_5099 : real := +0.0;
	D_5100 : word := 2#0000000000000000;
	D_5101 : int  := +00001;
	D_5102 : int  := +00000;
	D_5103 : int  := +00000;
	D_5104 : word := B#(  0, 0);
	D_5105 : word := B#(000,000);
	D_5106 : word := 2#0000000000000000;
	D_5107 : int  := +00000;
	D_5108 : int  := +00000;
	D_5109 : word := B#(  1,  1);	// State (1)
	D_5110 : word := B#(  0,  1);	//
	D_5111 : word := B#(  5,  8);	//
	D_5112 : int  := +00200;	//
	D_5113 : word := 2#0000000000000000;	//
	D_5114 : word := B#(  0,  0);	//
	D_5115 : word := B#(  1,  1);	// State (2)
	D_5116 : word := B#(  0,  0);	//
	D_5117 : word := B#(  0,  0);	//
	D_5118 : int  := +00000;	//
	D_5119 : word := 2#0000000000000000;	//
	D_5120 : word := B#(  0,  0);	//
	D_5121 : word := B#(  1,  1);	// State (3)
	D_5122 : word := B#(  0,  1);	//
	D_5123 : word := B#(  6,  1);	//
	D_5124 : int  := +00000;	//
	D_5125 : word := 2#0000000000000000;	//
	D_5126 : word := B#(  0,  0);	//
	D_5127 : word := B#(  1,  1);	// State (16)
	D_5128 : word := B#(  0,  1);	//
	D_5129 : word := B#(  15,  12);	//
	D_5130 : int  := +00000;	//
	D_5131 : word := 2#0000000000000000;	//
	D_5132 : word := B#(  0,  0);	//
	D_5133 : real := -150.000000000000;	//
	D_5134 : real := 150.000000000000;	//
	D_5135 : real := 0.000000000000;	//
	D_5136 : real := 1.500000000000;	//
	D_5137 : real := +0.0;	//
	D_5138 : int  := 00000;	//
	D_5139 : int  := 00000;	//
	D_5140 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_5141 : int  := 00000;	//
	D_5142 : int  := +00000;	//
	D_5143 : word  := B#(000,000);	//
	D_5144 : int  := +00000;	//
	D_5145 : real := 120.000000000000;	// Limit (1)
	D_5146 : real := +0.0;	//
	D_5147 : int  := +00000;	//
	D_5148 : word := 2#0000000000000000;	//
	D_5149 : int := +00000;	//
	D_5150 : real := -120.000000000000;	// Limit (2)
	D_5151 : real := +0.0;	//
	D_5152 : int  := +00000;	//
	D_5153 : word := 2#0000000000000000;	//
	D_5154 : int := +00000;	//
	D_5155 : word := B#(  2,  3);	//  010263 ( 02594 )
	D_5156 : word := 2#0000000000000100;	// MB TEMP CILINDRO 9
	D_5157 : real := +0.0;
	D_5158 : word := 2#0000000000000000;
	D_5159 : int  := +00001;
	D_5160 : int  := +00000;
	D_5161 : int  := +00000;
	D_5162 : word := B#(  0, 0);
	D_5163 : word := B#(000,000);
	D_5164 : word := 2#0000000000000000;
	D_5165 : int  := +00000;
	D_5166 : int  := +00000;
	D_5167 : word := B#(  1,  1);	// State (1)
	D_5168 : word := B#(  0,  1);	//
	D_5169 : word := B#(  5,  8);	//
	D_5170 : int  := +00200;	//
	D_5171 : word := 2#0000000000000000;	//
	D_5172 : word := B#(  0,  0);	//
	D_5173 : word := B#(  1,  1);	// State (2)
	D_5174 : word := B#(  0,  1);	//
	D_5175 : word := B#(  3,  4);	//
	D_5176 : int  := +00000;	//
	D_5177 : word := 2#0000000000000000;	//
	D_5178 : word := B#(  0,  0);	//
	D_5179 : word := B#(  1,  1);	// State (3)
	D_5180 : word := B#(  0,  0);	//
	D_5181 : word := B#(  0,  0);	//
	D_5182 : int  := +00000;	//
	D_5183 : word := 2#0000000000000000;	//
	D_5184 : word := B#(  0,  0);	//
	D_5185 : word := B#(  1,  1);	// State (16)
	D_5186 : word := B#(  0,  1);	//
	D_5187 : word := B#(  15,  12);	//
	D_5188 : int  := +00000;	//
	D_5189 : word := 2#0000000000000000;	//
	D_5190 : word := B#(  0,  0);	//
	D_5191 : real := 0.000000000000;	//
	D_5192 : real := 1300.000000000000;	//
	D_5193 : real := 0.000000000000;	//
	D_5194 : real := 0.000000000000;	//
	D_5195 : real := +0.0;	//
	D_5196 : int  := 00000;	//
	D_5197 : int  := 00000;	//
	D_5198 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_5199 : int  := 00000;	//
	D_5200 : int  := +00000;	//
	D_5201 : word  := B#(000,000);	//
	D_5202 : int  := +00000;	//
	D_5203 : real := 1110.000000000000;	// Limit (1)
	D_5204 : real := +0.0;	//
	D_5205 : int  := +00000;	//
	D_5206 : word := 2#0000000000000000;	//
	D_5207 : int := +00000;	//
	D_5208 : real := 1022.000000000000;	// Limit (2)
	D_5209 : real := +0.0;	//
	D_5210 : int  := +00000;	//
	D_5211 : word := 2#0000000000000000;	//
	D_5212 : int := +00000;	//
	D_5213 : word := B#(  2,  3);	//  010263D ( 02595 )
	D_5214 : word := 2#0000000000000100;	// MB CILINDRO TEMP 9 DESV.
	D_5215 : real := +0.0;
	D_5216 : word := 2#0000000000000000;
	D_5217 : int  := +00001;
	D_5218 : int  := +00000;
	D_5219 : int  := +00000;
	D_5220 : word := B#(  0, 0);
	D_5221 : word := B#(000,000);
	D_5222 : word := 2#0000000000000000;
	D_5223 : int  := +00000;
	D_5224 : int  := +00000;
	D_5225 : word := B#(  1,  1);	// State (1)
	D_5226 : word := B#(  0,  1);	//
	D_5227 : word := B#(  5,  8);	//
	D_5228 : int  := +00200;	//
	D_5229 : word := 2#0000000000000000;	//
	D_5230 : word := B#(  0,  0);	//
	D_5231 : word := B#(  1,  1);	// State (2)
	D_5232 : word := B#(  0,  0);	//
	D_5233 : word := B#(  0,  0);	//
	D_5234 : int  := +00000;	//
	D_5235 : word := 2#0000000000000000;	//
	D_5236 : word := B#(  0,  0);	//
	D_5237 : word := B#(  1,  1);	// State (3)
	D_5238 : word := B#(  0,  1);	//
	D_5239 : word := B#(  6,  1);	//
	D_5240 : int  := +00000;	//
	D_5241 : word := 2#0000000000000000;	//
	D_5242 : word := B#(  0,  0);	//
	D_5243 : word := B#(  1,  1);	// State (16)
	D_5244 : word := B#(  0,  1);	//
	D_5245 : word := B#(  15,  12);	//
	D_5246 : int  := +00000;	//
	D_5247 : word := 2#0000000000000000;	//
	D_5248 : word := B#(  0,  0);	//
	D_5249 : real := -150.000000000000;	//
	D_5250 : real := 150.000000000000;	//
	D_5251 : real := 0.000000000000;	//
	D_5252 : real := 1.500000000000;	//
	D_5253 : real := +0.0;	//
	D_5254 : int  := 00000;	//
	D_5255 : int  := 00000;	//
	D_5256 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_5257 : int  := 00000;	//
	D_5258 : int  := +00000;	//
	D_5259 : word  := B#(000,000);	//
	D_5260 : int  := +00000;	//
	D_5261 : real := 120.000000000000;	// Limit (1)
	D_5262 : real := +0.0;	//
	D_5263 : int  := +00000;	//
	D_5264 : word := 2#0000000000000000;	//
	D_5265 : int := +00000;	//
	D_5266 : real := -120.000000000000;	// Limit (2)
	D_5267 : real := +0.0;	//
	D_5268 : int  := +00000;	//
	D_5269 : word := 2#0000000000000000;	//
	D_5270 : int := +00000;	//
	D_5271 : word := B#(  2,  3);	//  010264 ( 02596 )
	D_5272 : word := 2#0000000000000100;	// MB TEMP CILINDRO 10
	D_5273 : real := +0.0;
	D_5274 : word := 2#0000000000000000;
	D_5275 : int  := +00001;
	D_5276 : int  := +00000;
	D_5277 : int  := +00000;
	D_5278 : word := B#(  0, 0);
	D_5279 : word := B#(000,000);
	D_5280 : word := 2#0000000000000000;
	D_5281 : int  := +00000;
	D_5282 : int  := +00000;
	D_5283 : word := B#(  1,  1);	// State (1)
	D_5284 : word := B#(  0,  1);	//
	D_5285 : word := B#(  5,  8);	//
	D_5286 : int  := +00200;	//
	D_5287 : word := 2#0000000000000000;	//
	D_5288 : word := B#(  0,  0);	//
	D_5289 : word := B#(  1,  1);	// State (2)
	D_5290 : word := B#(  0,  1);	//
	D_5291 : word := B#(  3,  4);	//
	D_5292 : int  := +00000;	//
	D_5293 : word := 2#0000000000000000;	//
	D_5294 : word := B#(  0,  0);	//
	D_5295 : word := B#(  1,  1);	// State (3)
	D_5296 : word := B#(  0,  0);	//
	D_5297 : word := B#(  0,  0);	//
	D_5298 : int  := +00000;	//
	D_5299 : word := 2#0000000000000000;	//
	D_5300 : word := B#(  0,  0);	//
	D_5301 : word := B#(  1,  1);	// State (16)
	D_5302 : word := B#(  0,  1);	//
	D_5303 : word := B#(  15,  12);	//
	D_5304 : int  := +00000;	//
	D_5305 : word := 2#0000000000000000;	//
	D_5306 : word := B#(  0,  0);	//
	D_5307 : real := 0.000000000000;	//
	D_5308 : real := 1300.000000000000;	//
	D_5309 : real := 0.000000000000;	//
	D_5310 : real := 0.000000000000;	//
	D_5311 : real := +0.0;	//
	D_5312 : int  := 00000;	//
	D_5313 : int  := 00000;	//
	D_5314 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_5315 : int  := 00000;	//
	D_5316 : int  := +00000;	//
	D_5317 : word  := B#(000,000);	//
	D_5318 : int  := +00000;	//
	D_5319 : real := 1110.000000000000;	// Limit (1)
	D_5320 : real := +0.0;	//
	D_5321 : int  := +00000;	//
	D_5322 : word := 2#0000000000000000;	//
	D_5323 : int := +00000;	//
	D_5324 : real := 1022.000000000000;	// Limit (2)
	D_5325 : real := +0.0;	//
	D_5326 : int  := +00000;	//
	D_5327 : word := 2#0000000000000000;	//
	D_5328 : int := +00000;	//
	D_5329 : word := B#(  2,  3);	//  010264D ( 02597 )
	D_5330 : word := 2#0000000000000100;	// MB CILINDRO TEMP 10 DESV.
	D_5331 : real := +0.0;
	D_5332 : word := 2#0000000000000000;
	D_5333 : int  := +00001;
	D_5334 : int  := +00000;
	D_5335 : int  := +00000;
	D_5336 : word := B#(  0, 0);
	D_5337 : word := B#(000,000);
	D_5338 : word := 2#0000000000000000;
	D_5339 : int  := +00000;
	D_5340 : int  := +00000;
	D_5341 : word := B#(  1,  1);	// State (1)
	D_5342 : word := B#(  0,  1);	//
	D_5343 : word := B#(  5,  8);	//
	D_5344 : int  := +00200;	//
	D_5345 : word := 2#0000000000000000;	//
	D_5346 : word := B#(  0,  0);	//
	D_5347 : word := B#(  1,  1);	// State (2)
	D_5348 : word := B#(  0,  0);	//
	D_5349 : word := B#(  0,  0);	//
	D_5350 : int  := +00000;	//
	D_5351 : word := 2#0000000000000000;	//
	D_5352 : word := B#(  0,  0);	//
	D_5353 : word := B#(  1,  1);	// State (3)
	D_5354 : word := B#(  0,  1);	//
	D_5355 : word := B#(  6,  1);	//
	D_5356 : int  := +00000;	//
	D_5357 : word := 2#0000000000000000;	//
	D_5358 : word := B#(  0,  0);	//
	D_5359 : word := B#(  1,  1);	// State (16)
	D_5360 : word := B#(  0,  1);	//
	D_5361 : word := B#(  15,  12);	//
	D_5362 : int  := +00000;	//
	D_5363 : word := 2#0000000000000000;	//
	D_5364 : word := B#(  0,  0);	//
	D_5365 : real := -150.000000000000;	//
	D_5366 : real := 150.000000000000;	//
	D_5367 : real := 0.000000000000;	//
	D_5368 : real := 1.500000000000;	//
	D_5369 : real := +0.0;	//
	D_5370 : int  := 00000;	//
	D_5371 : int  := 00000;	//
	D_5372 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_5373 : int  := 00000;	//
	D_5374 : int  := +00000;	//
	D_5375 : word  := B#(000,000);	//
	D_5376 : int  := +00000;	//
	D_5377 : real := 120.000000000000;	// Limit (1)
	D_5378 : real := +0.0;	//
	D_5379 : int  := +00000;	//
	D_5380 : word := 2#0000000000000000;	//
	D_5381 : int := +00000;	//
	D_5382 : real := -120.000000000000;	// Limit (2)
	D_5383 : real := +0.0;	//
	D_5384 : int  := +00000;	//
	D_5385 : word := 2#0000000000000000;	//
	D_5386 : int := +00000;	//
	D_5387 : word := B#(  2,  3);	//  010265 ( 02598 )
	D_5388 : word := 2#0000000000000100;	// MB TEMP CILINDRO 11
	D_5389 : real := +0.0;
	D_5390 : word := 2#0000000000000000;
	D_5391 : int  := +00001;
	D_5392 : int  := +00000;
	D_5393 : int  := +00000;
	D_5394 : word := B#(  0, 0);
	D_5395 : word := B#(000,000);
	D_5396 : word := 2#0000000000000000;
	D_5397 : int  := +00000;
	D_5398 : int  := +00000;
	D_5399 : word := B#(  1,  1);	// State (1)
	D_5400 : word := B#(  0,  1);	//
	D_5401 : word := B#(  5,  8);	//
	D_5402 : int  := +00200;	//
	D_5403 : word := 2#0000000000000000;	//
	D_5404 : word := B#(  0,  0);	//
	D_5405 : word := B#(  1,  1);	// State (2)
	D_5406 : word := B#(  0,  1);	//
	D_5407 : word := B#(  3,  4);	//
	D_5408 : int  := +00000;	//
	D_5409 : word := 2#0000000000000000;	//
	D_5410 : word := B#(  0,  0);	//
	D_5411 : word := B#(  1,  1);	// State (3)
	D_5412 : word := B#(  0,  0);	//
	D_5413 : word := B#(  0,  0);	//
	D_5414 : int  := +00000;	//
	D_5415 : word := 2#0000000000000000;	//
	D_5416 : word := B#(  0,  0);	//
	D_5417 : word := B#(  1,  1);	// State (16)
	D_5418 : word := B#(  0,  1);	//
	D_5419 : word := B#(  15,  12);	//
	D_5420 : int  := +00000;	//
	D_5421 : word := 2#0000000000000000;	//
	D_5422 : word := B#(  0,  0);	//
	D_5423 : real := 0.000000000000;	//
	D_5424 : real := 1300.000000000000;	//
	D_5425 : real := 0.000000000000;	//
	D_5426 : real := 0.000000000000;	//
	D_5427 : real := +0.0;	//
	D_5428 : int  := 00000;	//
	D_5429 : int  := 00000;	//
	D_5430 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_5431 : int  := 00000;	//
	D_5432 : int  := +00000;	//
	D_5433 : word  := B#(000,000);	//
	D_5434 : int  := +00000;	//
	D_5435 : real := 1110.000000000000;	// Limit (1)
	D_5436 : real := +0.0;	//
	D_5437 : int  := +00000;	//
	D_5438 : word := 2#0000000000000000;	//
	D_5439 : int := +00000;	//
	D_5440 : real := 1022.000000000000;	// Limit (2)
	D_5441 : real := +0.0;	//
	D_5442 : int  := +00000;	//
	D_5443 : word := 2#0000000000000000;	//
	D_5444 : int := +00000;	//
	D_5445 : word := B#(  2,  3);	//  010265D ( 02599 )
	D_5446 : word := 2#0000000000000100;	// MB CILINDRO TEMP 11 DESV.
	D_5447 : real := +0.0;
	D_5448 : word := 2#0000000000000000;
	D_5449 : int  := +00001;
	D_5450 : int  := +00000;
	D_5451 : int  := +00000;
	D_5452 : word := B#(  0, 0);
	D_5453 : word := B#(000,000);
	D_5454 : word := 2#0000000000000000;
	D_5455 : int  := +00000;
	D_5456 : int  := +00000;
	D_5457 : word := B#(  1,  1);	// State (1)
	D_5458 : word := B#(  0,  1);	//
	D_5459 : word := B#(  5,  8);	//
	D_5460 : int  := +00200;	//
	D_5461 : word := 2#0000000000000000;	//
	D_5462 : word := B#(  0,  0);	//
	D_5463 : word := B#(  1,  1);	// State (2)
	D_5464 : word := B#(  0,  0);	//
	D_5465 : word := B#(  0,  0);	//
	D_5466 : int  := +00000;	//
	D_5467 : word := 2#0000000000000000;	//
	D_5468 : word := B#(  0,  0);	//
	D_5469 : word := B#(  1,  1);	// State (3)
	D_5470 : word := B#(  0,  1);	//
	D_5471 : word := B#(  6,  1);	//
	D_5472 : int  := +00000;	//
	D_5473 : word := 2#0000000000000000;	//
	D_5474 : word := B#(  0,  0);	//
	D_5475 : word := B#(  1,  1);	// State (16)
	D_5476 : word := B#(  0,  1);	//
	D_5477 : word := B#(  15,  12);	//
	D_5478 : int  := +00000;	//
	D_5479 : word := 2#0000000000000000;	//
	D_5480 : word := B#(  0,  0);	//
	D_5481 : real := -150.000000000000;	//
	D_5482 : real := 150.000000000000;	//
	D_5483 : real := 0.000000000000;	//
	D_5484 : real := 1.500000000000;	//
	D_5485 : real := +0.0;	//
	D_5486 : int  := 00000;	//
	D_5487 : int  := 00000;	//
	D_5488 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_5489 : int  := 00000;	//
	D_5490 : int  := +00000;	//
	D_5491 : word  := B#(000,000);	//
	D_5492 : int  := +00000;	//
	D_5493 : real := 120.000000000000;	// Limit (1)
	D_5494 : real := +0.0;	//
	D_5495 : int  := +00000;	//
	D_5496 : word := 2#0000000000000000;	//
	D_5497 : int := +00000;	//
	D_5498 : real := -120.000000000000;	// Limit (2)
	D_5499 : real := +0.0;	//
	D_5500 : int  := +00000;	//
	D_5501 : word := 2#0000000000000000;	//
	D_5502 : int := +00000;	//
	D_5503 : word := B#(  2,  3);	//  010266 ( 02600 )
	D_5504 : word := 2#0000000000000100;	// MB TEMP CILINDRO 12
	D_5505 : real := +0.0;
	D_5506 : word := 2#0000000000000000;
	D_5507 : int  := +00001;
	D_5508 : int  := +00000;
	D_5509 : int  := +00000;
	D_5510 : word := B#(  0, 0);
	D_5511 : word := B#(000,000);
	D_5512 : word := 2#0000000000000000;
	D_5513 : int  := +00000;
	D_5514 : int  := +00000;
	D_5515 : word := B#(  1,  1);	// State (1)
	D_5516 : word := B#(  0,  1);	//
	D_5517 : word := B#(  5,  8);	//
	D_5518 : int  := +00200;	//
	D_5519 : word := 2#0000000000000000;	//
	D_5520 : word := B#(  0,  0);	//
	D_5521 : word := B#(  1,  1);	// State (2)
	D_5522 : word := B#(  0,  1);	//
	D_5523 : word := B#(  3,  4);	//
	D_5524 : int  := +00000;	//
	D_5525 : word := 2#0000000000000000;	//
	D_5526 : word := B#(  0,  0);	//
	D_5527 : word := B#(  1,  1);	// State (3)
	D_5528 : word := B#(  0,  0);	//
	D_5529 : word := B#(  0,  0);	//
	D_5530 : int  := +00000;	//
	D_5531 : word := 2#0000000000000000;	//
	D_5532 : word := B#(  0,  0);	//
	D_5533 : word := B#(  1,  1);	// State (16)
	D_5534 : word := B#(  0,  1);	//
	D_5535 : word := B#(  15,  12);	//
	D_5536 : int  := +00000;	//
	D_5537 : word := 2#0000000000000000;	//
	D_5538 : word := B#(  0,  0);	//
	D_5539 : real := 0.000000000000;	//
	D_5540 : real := 1300.000000000000;	//
	D_5541 : real := 0.000000000000;	//
	D_5542 : real := 0.000000000000;	//
	D_5543 : real := +0.0;	//
	D_5544 : int  := 00000;	//
	D_5545 : int  := 00000;	//
	D_5546 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_5547 : int  := 00000;	//
	D_5548 : int  := +00000;	//
	D_5549 : word  := B#(000,000);	//
	D_5550 : int  := +00000;	//
	D_5551 : real := 1110.000000000000;	// Limit (1)
	D_5552 : real := +0.0;	//
	D_5553 : int  := +00000;	//
	D_5554 : word := 2#0000000000000000;	//
	D_5555 : int := +00000;	//
	D_5556 : real := 1022.000000000000;	// Limit (2)
	D_5557 : real := +0.0;	//
	D_5558 : int  := +00000;	//
	D_5559 : word := 2#0000000000000000;	//
	D_5560 : int := +00000;	//
	D_5561 : word := B#(  2,  3);	//  010266D ( 02601 )
	D_5562 : word := 2#0000000000000100;	// MB CILINDRO TEMP 12 DESV.
	D_5563 : real := +0.0;
	D_5564 : word := 2#0000000000000000;
	D_5565 : int  := +00001;
	D_5566 : int  := +00000;
	D_5567 : int  := +00000;
	D_5568 : word := B#(  0, 0);
	D_5569 : word := B#(000,000);
	D_5570 : word := 2#0000000000000000;
	D_5571 : int  := +00000;
	D_5572 : int  := +00000;
	D_5573 : word := B#(  1,  1);	// State (1)
	D_5574 : word := B#(  0,  1);	//
	D_5575 : word := B#(  5,  8);	//
	D_5576 : int  := +00200;	//
	D_5577 : word := 2#0000000000000000;	//
	D_5578 : word := B#(  0,  0);	//
	D_5579 : word := B#(  1,  1);	// State (2)
	D_5580 : word := B#(  0,  0);	//
	D_5581 : word := B#(  0,  0);	//
	D_5582 : int  := +00000;	//
	D_5583 : word := 2#0000000000000000;	//
	D_5584 : word := B#(  0,  0);	//
	D_5585 : word := B#(  1,  1);	// State (3)
	D_5586 : word := B#(  0,  1);	//
	D_5587 : word := B#(  6,  1);	//
	D_5588 : int  := +00000;	//
	D_5589 : word := 2#0000000000000000;	//
	D_5590 : word := B#(  0,  0);	//
	D_5591 : word := B#(  1,  1);	// State (16)
	D_5592 : word := B#(  0,  1);	//
	D_5593 : word := B#(  15,  12);	//
	D_5594 : int  := +00000;	//
	D_5595 : word := 2#0000000000000000;	//
	D_5596 : word := B#(  0,  0);	//
	D_5597 : real := -150.000000000000;	//
	D_5598 : real := 150.000000000000;	//
	D_5599 : real := 0.000000000000;	//
	D_5600 : real := 1.500000000000;	//
	D_5601 : real := +0.0;	//
	D_5602 : int  := 00000;	//
	D_5603 : int  := 00000;	//
	D_5604 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_5605 : int  := 00000;	//
	D_5606 : int  := +00000;	//
	D_5607 : word  := B#(000,000);	//
	D_5608 : int  := +00000;	//
	D_5609 : real := 120.000000000000;	// Limit (1)
	D_5610 : real := +0.0;	//
	D_5611 : int  := +00000;	//
	D_5612 : word := 2#0000000000000000;	//
	D_5613 : int := +00000;	//
	D_5614 : real := -120.000000000000;	// Limit (2)
	D_5615 : real := +0.0;	//
	D_5616 : int  := +00000;	//
	D_5617 : word := 2#0000000000000000;	//
	D_5618 : int := +00000;	//
	D_5619 : word := B#(  2,  3);	//  010267 ( 02602 )
	D_5620 : word := 2#0000000000000100;	// MB TEMP CILINDRO 13
	D_5621 : real := +0.0;
	D_5622 : word := 2#0000000000000000;
	D_5623 : int  := +00001;
	D_5624 : int  := +00000;
	D_5625 : int  := +00000;
	D_5626 : word := B#(  0, 0);
	D_5627 : word := B#(000,000);
	D_5628 : word := 2#0000000000000000;
	D_5629 : int  := +00000;
	D_5630 : int  := +00000;
	D_5631 : word := B#(  1,  1);	// State (1)
	D_5632 : word := B#(  0,  1);	//
	D_5633 : word := B#(  5,  8);	//
	D_5634 : int  := +00200;	//
	D_5635 : word := 2#0000000000000000;	//
	D_5636 : word := B#(  0,  0);	//
	D_5637 : word := B#(  1,  1);	// State (2)
	D_5638 : word := B#(  0,  1);	//
	D_5639 : word := B#(  3,  4);	//
	D_5640 : int  := +00000;	//
	D_5641 : word := 2#0000000000000000;	//
	D_5642 : word := B#(  0,  0);	//
	D_5643 : word := B#(  1,  1);	// State (3)
	D_5644 : word := B#(  0,  0);	//
	D_5645 : word := B#(  0,  0);	//
	D_5646 : int  := +00000;	//
	D_5647 : word := 2#0000000000000000;	//
	D_5648 : word := B#(  0,  0);	//
	D_5649 : word := B#(  1,  1);	// State (16)
	D_5650 : word := B#(  0,  1);	//
	D_5651 : word := B#(  15,  12);	//
	D_5652 : int  := +00000;	//
	D_5653 : word := 2#0000000000000000;	//
	D_5654 : word := B#(  0,  0);	//
	D_5655 : real := 0.000000000000;	//
	D_5656 : real := 1300.000000000000;	//
	D_5657 : real := 0.000000000000;	//
	D_5658 : real := 0.000000000000;	//
	D_5659 : real := +0.0;	//
	D_5660 : int  := 00000;	//
	D_5661 : int  := 00000;	//
	D_5662 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_5663 : int  := 00000;	//
	D_5664 : int  := +00000;	//
	D_5665 : word  := B#(000,000);	//
	D_5666 : int  := +00000;	//
	D_5667 : real := 1110.000000000000;	// Limit (1)
	D_5668 : real := +0.0;	//
	D_5669 : int  := +00000;	//
	D_5670 : word := 2#0000000000000000;	//
	D_5671 : int := +00000;	//
	D_5672 : real := 1022.000000000000;	// Limit (2)
	D_5673 : real := +0.0;	//
	D_5674 : int  := +00000;	//
	D_5675 : word := 2#0000000000000000;	//
	D_5676 : int := +00000;	//
	D_5677 : word := B#(  2,  3);	//  010267D ( 02603 )
	D_5678 : word := 2#0000000000000100;	// MB CILINDRO TEMP 13 DESV.
	D_5679 : real := +0.0;
	D_5680 : word := 2#0000000000000000;
	D_5681 : int  := +00001;
	D_5682 : int  := +00000;
	D_5683 : int  := +00000;
	D_5684 : word := B#(  0, 0);
	D_5685 : word := B#(000,000);
	D_5686 : word := 2#0000000000000000;
	D_5687 : int  := +00000;
	D_5688 : int  := +00000;
	D_5689 : word := B#(  1,  1);	// State (1)
	D_5690 : word := B#(  0,  1);	//
	D_5691 : word := B#(  5,  8);	//
	D_5692 : int  := +00200;	//
	D_5693 : word := 2#0000000000000000;	//
	D_5694 : word := B#(  0,  0);	//
	D_5695 : word := B#(  1,  1);	// State (2)
	D_5696 : word := B#(  0,  0);	//
	D_5697 : word := B#(  0,  0);	//
	D_5698 : int  := +00000;	//
	D_5699 : word := 2#0000000000000000;	//
	D_5700 : word := B#(  0,  0);	//
	D_5701 : word := B#(  1,  1);	// State (3)
	D_5702 : word := B#(  0,  1);	//
	D_5703 : word := B#(  6,  1);	//
	D_5704 : int  := +00000;	//
	D_5705 : word := 2#0000000000000000;	//
	D_5706 : word := B#(  0,  0);	//
	D_5707 : word := B#(  1,  1);	// State (16)
	D_5708 : word := B#(  0,  1);	//
	D_5709 : word := B#(  15,  12);	//
	D_5710 : int  := +00000;	//
	D_5711 : word := 2#0000000000000000;	//
	D_5712 : word := B#(  0,  0);	//
	D_5713 : real := -150.000000000000;	//
	D_5714 : real := 150.000000000000;	//
	D_5715 : real := 0.000000000000;	//
	D_5716 : real := 1.500000000000;	//
	D_5717 : real := +0.0;	//
	D_5718 : int  := 00000;	//
	D_5719 : int  := 00000;	//
	D_5720 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_5721 : int  := 00000;	//
	D_5722 : int  := +00000;	//
	D_5723 : word  := B#(000,000);	//
	D_5724 : int  := +00000;	//
	D_5725 : real := 120.000000000000;	// Limit (1)
	D_5726 : real := +0.0;	//
	D_5727 : int  := +00000;	//
	D_5728 : word := 2#0000000000000000;	//
	D_5729 : int := +00000;	//
	D_5730 : real := -120.000000000000;	// Limit (2)
	D_5731 : real := +0.0;	//
	D_5732 : int  := +00000;	//
	D_5733 : word := 2#0000000000000000;	//
	D_5734 : int := +00000;	//
	D_5735 : word := B#(  2,  3);	//  010268 ( 02604 )
	D_5736 : word := 2#0000000000000100;	// MB TEMP CILINDRO 14
	D_5737 : real := +0.0;
	D_5738 : word := 2#0000000000000000;
	D_5739 : int  := +00001;
	D_5740 : int  := +00000;
	D_5741 : int  := +00000;
	D_5742 : word := B#(  0, 0);
	D_5743 : word := B#(000,000);
	D_5744 : word := 2#0000000000000000;
	D_5745 : int  := +00000;
	D_5746 : int  := +00000;
	D_5747 : word := B#(  1,  1);	// State (1)
	D_5748 : word := B#(  0,  1);	//
	D_5749 : word := B#(  5,  8);	//
	D_5750 : int  := +00200;	//
	D_5751 : word := 2#0000000000000000;	//
	D_5752 : word := B#(  0,  0);	//
	D_5753 : word := B#(  1,  1);	// State (2)
	D_5754 : word := B#(  0,  1);	//
	D_5755 : word := B#(  3,  4);	//
	D_5756 : int  := +00000;	//
	D_5757 : word := 2#0000000000000000;	//
	D_5758 : word := B#(  0,  0);	//
	D_5759 : word := B#(  1,  1);	// State (3)
	D_5760 : word := B#(  0,  0);	//
	D_5761 : word := B#(  0,  0);	//
	D_5762 : int  := +00000;	//
	D_5763 : word := 2#0000000000000000;	//
	D_5764 : word := B#(  0,  0);	//
	D_5765 : word := B#(  1,  1);	// State (16)
	D_5766 : word := B#(  0,  1);	//
	D_5767 : word := B#(  15,  12);	//
	D_5768 : int  := +00000;	//
	D_5769 : word := 2#0000000000000000;	//
	D_5770 : word := B#(  0,  0);	//
	D_5771 : real := 0.000000000000;	//
	D_5772 : real := 1300.000000000000;	//
	D_5773 : real := 0.000000000000;	//
	D_5774 : real := 0.000000000000;	//
	D_5775 : real := +0.0;	//
	D_5776 : int  := 00000;	//
	D_5777 : int  := 00000;	//
	D_5778 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_5779 : int  := 00000;	//
	D_5780 : int  := +00000;	//
	D_5781 : word  := B#(000,000);	//
	D_5782 : int  := +00000;	//
	D_5783 : real := 1110.000000000000;	// Limit (1)
	D_5784 : real := +0.0;	//
	D_5785 : int  := +00000;	//
	D_5786 : word := 2#0000000000000000;	//
	D_5787 : int := +00000;	//
	D_5788 : real := 1022.000000000000;	// Limit (2)
	D_5789 : real := +0.0;	//
	D_5790 : int  := +00000;	//
	D_5791 : word := 2#0000000000000000;	//
	D_5792 : int := +00000;	//
	D_5793 : word := B#(  2,  3);	//  010268D ( 02605 )
	D_5794 : word := 2#0000000000000100;	// MB CILINDRO TEMP 14 DESV.
	D_5795 : real := +0.0;
	D_5796 : word := 2#0000000000000000;
	D_5797 : int  := +00001;
	D_5798 : int  := +00000;
	D_5799 : int  := +00000;
	D_5800 : word := B#(  0, 0);
	D_5801 : word := B#(000,000);
	D_5802 : word := 2#0000000000000000;
	D_5803 : int  := +00000;
	D_5804 : int  := +00000;
	D_5805 : word := B#(  1,  1);	// State (1)
	D_5806 : word := B#(  0,  1);	//
	D_5807 : word := B#(  5,  8);	//
	D_5808 : int  := +00200;	//
	D_5809 : word := 2#0000000000000000;	//
	D_5810 : word := B#(  0,  0);	//
	D_5811 : word := B#(  1,  1);	// State (2)
	D_5812 : word := B#(  0,  0);	//
	D_5813 : word := B#(  0,  0);	//
	D_5814 : int  := +00000;	//
	D_5815 : word := 2#0000000000000000;	//
	D_5816 : word := B#(  0,  0);	//
	D_5817 : word := B#(  1,  1);	// State (3)
	D_5818 : word := B#(  0,  1);	//
	D_5819 : word := B#(  6,  1);	//
	D_5820 : int  := +00000;	//
	D_5821 : word := 2#0000000000000000;	//
	D_5822 : word := B#(  0,  0);	//
	D_5823 : word := B#(  1,  1);	// State (16)
	D_5824 : word := B#(  0,  1);	//
	D_5825 : word := B#(  15,  12);	//
	D_5826 : int  := +00000;	//
	D_5827 : word := 2#0000000000000000;	//
	D_5828 : word := B#(  0,  0);	//
	D_5829 : real := -150.000000000000;	//
	D_5830 : real := 150.000000000000;	//
	D_5831 : real := 0.000000000000;	//
	D_5832 : real := 1.500000000000;	//
	D_5833 : real := +0.0;	//
	D_5834 : int  := 00000;	//
	D_5835 : int  := 00000;	//
	D_5836 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_5837 : int  := 00000;	//
	D_5838 : int  := +00000;	//
	D_5839 : word  := B#(000,000);	//
	D_5840 : int  := +00000;	//
	D_5841 : real := 120.000000000000;	// Limit (1)
	D_5842 : real := +0.0;	//
	D_5843 : int  := +00000;	//
	D_5844 : word := 2#0000000000000000;	//
	D_5845 : int := +00000;	//
	D_5846 : real := -120.000000000000;	// Limit (2)
	D_5847 : real := +0.0;	//
	D_5848 : int  := +00000;	//
	D_5849 : word := 2#0000000000000000;	//
	D_5850 : int := +00000;	//
	D_5851 : word := B#(  2,  3);	//  010269 ( 02606 )
	D_5852 : word := 2#0000000000000100;	// MB TEMP CILINDRO 15
	D_5853 : real := +0.0;
	D_5854 : word := 2#0000000000000000;
	D_5855 : int  := +00001;
	D_5856 : int  := +00000;
	D_5857 : int  := +00000;
	D_5858 : word := B#(  0, 0);
	D_5859 : word := B#(000,000);
	D_5860 : word := 2#0000000000000000;
	D_5861 : int  := +00000;
	D_5862 : int  := +00000;
	D_5863 : word := B#(  1,  1);	// State (1)
	D_5864 : word := B#(  0,  1);	//
	D_5865 : word := B#(  5,  8);	//
	D_5866 : int  := +00200;	//
	D_5867 : word := 2#0000000000000000;	//
	D_5868 : word := B#(  0,  0);	//
	D_5869 : word := B#(  1,  1);	// State (2)
	D_5870 : word := B#(  0,  1);	//
	D_5871 : word := B#(  3,  4);	//
	D_5872 : int  := +00000;	//
	D_5873 : word := 2#0000000000000000;	//
	D_5874 : word := B#(  0,  0);	//
	D_5875 : word := B#(  1,  1);	// State (3)
	D_5876 : word := B#(  0,  0);	//
	D_5877 : word := B#(  0,  0);	//
	D_5878 : int  := +00000;	//
	D_5879 : word := 2#0000000000000000;	//
	D_5880 : word := B#(  0,  0);	//
	D_5881 : word := B#(  1,  1);	// State (16)
	D_5882 : word := B#(  0,  1);	//
	D_5883 : word := B#(  15,  12);	//
	D_5884 : int  := +00000;	//
	D_5885 : word := 2#0000000000000000;	//
	D_5886 : word := B#(  0,  0);	//
	D_5887 : real := 0.000000000000;	//
	D_5888 : real := 1300.000000000000;	//
	D_5889 : real := 0.000000000000;	//
	D_5890 : real := 0.000000000000;	//
	D_5891 : real := +0.0;	//
	D_5892 : int  := 00000;	//
	D_5893 : int  := 00000;	//
	D_5894 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_5895 : int  := 00000;	//
	D_5896 : int  := +00000;	//
	D_5897 : word  := B#(000,000);	//
	D_5898 : int  := +00000;	//
	D_5899 : real := 1110.000000000000;	// Limit (1)
	D_5900 : real := +0.0;	//
	D_5901 : int  := +00000;	//
	D_5902 : word := 2#0000000000000000;	//
	D_5903 : int := +00000;	//
	D_5904 : real := 1022.000000000000;	// Limit (2)
	D_5905 : real := +0.0;	//
	D_5906 : int  := +00000;	//
	D_5907 : word := 2#0000000000000000;	//
	D_5908 : int := +00000;	//
	D_5909 : word := B#(  2,  3);	//  010269D ( 02607 )
	D_5910 : word := 2#0000000000000100;	// MB CILINDRO TEMP 15 DESV.
	D_5911 : real := +0.0;
	D_5912 : word := 2#0000000000000000;
	D_5913 : int  := +00001;
	D_5914 : int  := +00000;
	D_5915 : int  := +00000;
	D_5916 : word := B#(  0, 0);
	D_5917 : word := B#(000,000);
	D_5918 : word := 2#0000000000000000;
	D_5919 : int  := +00000;
	D_5920 : int  := +00000;
	D_5921 : word := B#(  1,  1);	// State (1)
	D_5922 : word := B#(  0,  1);	//
	D_5923 : word := B#(  5,  8);	//
	D_5924 : int  := +00200;	//
	D_5925 : word := 2#0000000000000000;	//
	D_5926 : word := B#(  0,  0);	//
	D_5927 : word := B#(  1,  1);	// State (2)
	D_5928 : word := B#(  0,  0);	//
	D_5929 : word := B#(  0,  0);	//
	D_5930 : int  := +00000;	//
	D_5931 : word := 2#0000000000000000;	//
	D_5932 : word := B#(  0,  0);	//
	D_5933 : word := B#(  1,  1);	// State (3)
	D_5934 : word := B#(  0,  1);	//
	D_5935 : word := B#(  6,  1);	//
	D_5936 : int  := +00000;	//
	D_5937 : word := 2#0000000000000000;	//
	D_5938 : word := B#(  0,  0);	//
	D_5939 : word := B#(  1,  1);	// State (16)
	D_5940 : word := B#(  0,  1);	//
	D_5941 : word := B#(  15,  12);	//
	D_5942 : int  := +00000;	//
	D_5943 : word := 2#0000000000000000;	//
	D_5944 : word := B#(  0,  0);	//
	D_5945 : real := -150.000000000000;	//
	D_5946 : real := 150.000000000000;	//
	D_5947 : real := 0.000000000000;	//
	D_5948 : real := 1.500000000000;	//
	D_5949 : real := +0.0;	//
	D_5950 : int  := 00000;	//
	D_5951 : int  := 00000;	//
	D_5952 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_5953 : int  := 00000;	//
	D_5954 : int  := +00000;	//
	D_5955 : word  := B#(000,000);	//
	D_5956 : int  := +00000;	//
	D_5957 : real := 120.000000000000;	// Limit (1)
	D_5958 : real := +0.0;	//
	D_5959 : int  := +00000;	//
	D_5960 : word := 2#0000000000000000;	//
	D_5961 : int := +00000;	//
	D_5962 : real := -120.000000000000;	// Limit (2)
	D_5963 : real := +0.0;	//
	D_5964 : int  := +00000;	//
	D_5965 : word := 2#0000000000000000;	//
	D_5966 : int := +00000;	//
	D_5967 : word := B#(  2,  3);	//  010270 ( 02608 )
	D_5968 : word := 2#0000000000000100;	// MB TEMP CILINDRO 16
	D_5969 : real := +0.0;
	D_5970 : word := 2#0000000000000000;
	D_5971 : int  := +00001;
	D_5972 : int  := +00000;
	D_5973 : int  := +00000;
	D_5974 : word := B#(  0, 0);
	D_5975 : word := B#(000,000);
	D_5976 : word := 2#0000000000000000;
	D_5977 : int  := +00000;
	D_5978 : int  := +00000;
	D_5979 : word := B#(  1,  1);	// State (1)
	D_5980 : word := B#(  0,  1);	//
	D_5981 : word := B#(  5,  8);	//
	D_5982 : int  := +00200;	//
	D_5983 : word := 2#0000000000000000;	//
	D_5984 : word := B#(  0,  0);	//
	D_5985 : word := B#(  1,  1);	// State (2)
	D_5986 : word := B#(  0,  1);	//
	D_5987 : word := B#(  3,  4);	//
	D_5988 : int  := +00000;	//
	D_5989 : word := 2#0000000000000000;	//
	D_5990 : word := B#(  0,  0);	//
	D_5991 : word := B#(  1,  1);	// State (3)
	D_5992 : word := B#(  0,  0);	//
	D_5993 : word := B#(  0,  0);	//
	D_5994 : int  := +00000;	//
	D_5995 : word := 2#0000000000000000;	//
	D_5996 : word := B#(  0,  0);	//
	D_5997 : word := B#(  1,  1);	// State (16)
	D_5998 : word := B#(  0,  1);	//
	D_5999 : word := B#(  15,  12);	//
	D_6000 : int  := +00000;	//
	D_6001 : word := 2#0000000000000000;	//
	D_6002 : word := B#(  0,  0);	//
	D_6003 : real := 0.000000000000;	//
	D_6004 : real := 1300.000000000000;	//
	D_6005 : real := 0.000000000000;	//
	D_6006 : real := 0.000000000000;	//
	D_6007 : real := +0.0;	//
	D_6008 : int  := 00000;	//
	D_6009 : int  := 00000;	//
	D_6010 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_6011 : int  := 00000;	//
	D_6012 : int  := +00000;	//
	D_6013 : word  := B#(000,000);	//
	D_6014 : int  := +00000;	//
	D_6015 : real := 1110.000000000000;	// Limit (1)
	D_6016 : real := +0.0;	//
	D_6017 : int  := +00000;	//
	D_6018 : word := 2#0000000000000000;	//
	D_6019 : int := +00000;	//
	D_6020 : real := 1022.000000000000;	// Limit (2)
	D_6021 : real := +0.0;	//
	D_6022 : int  := +00000;	//
	D_6023 : word := 2#0000000000000000;	//
	D_6024 : int := +00000;	//
	D_6025 : word := B#(  2,  3);	//  010270D ( 02609 )
	D_6026 : word := 2#0000000000000100;	// MB CILINDRO TEMP 16 DESV.
	D_6027 : real := +0.0;
	D_6028 : word := 2#0000000000000000;
	D_6029 : int  := +00001;
	D_6030 : int  := +00000;
	D_6031 : int  := +00000;
	D_6032 : word := B#(  0, 0);
	D_6033 : word := B#(000,000);
	D_6034 : word := 2#0000000000000000;
	D_6035 : int  := +00000;
	D_6036 : int  := +00000;
	D_6037 : word := B#(  1,  1);	// State (1)
	D_6038 : word := B#(  0,  1);	//
	D_6039 : word := B#(  5,  8);	//
	D_6040 : int  := +00200;	//
	D_6041 : word := 2#0000000000000000;	//
	D_6042 : word := B#(  0,  0);	//
	D_6043 : word := B#(  1,  1);	// State (2)
	D_6044 : word := B#(  0,  0);	//
	D_6045 : word := B#(  0,  0);	//
	D_6046 : int  := +00000;	//
	D_6047 : word := 2#0000000000000000;	//
	D_6048 : word := B#(  0,  0);	//
	D_6049 : word := B#(  1,  1);	// State (3)
	D_6050 : word := B#(  0,  1);	//
	D_6051 : word := B#(  6,  1);	//
	D_6052 : int  := +00000;	//
	D_6053 : word := 2#0000000000000000;	//
	D_6054 : word := B#(  0,  0);	//
	D_6055 : word := B#(  1,  1);	// State (16)
	D_6056 : word := B#(  0,  1);	//
	D_6057 : word := B#(  15,  12);	//
	D_6058 : int  := +00000;	//
	D_6059 : word := 2#0000000000000000;	//
	D_6060 : word := B#(  0,  0);	//
	D_6061 : real := -150.000000000000;	//
	D_6062 : real := 150.000000000000;	//
	D_6063 : real := 0.000000000000;	//
	D_6064 : real := 1.500000000000;	//
	D_6065 : real := +0.0;	//
	D_6066 : int  := 00000;	//
	D_6067 : int  := 00000;	//
	D_6068 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_6069 : int  := 00000;	//
	D_6070 : int  := +00000;	//
	D_6071 : word  := B#(000,000);	//
	D_6072 : int  := +00000;	//
	D_6073 : real := 120.000000000000;	// Limit (1)
	D_6074 : real := +0.0;	//
	D_6075 : int  := +00000;	//
	D_6076 : word := 2#0000000000000000;	//
	D_6077 : int := +00000;	//
	D_6078 : real := -120.000000000000;	// Limit (2)
	D_6079 : real := +0.0;	//
	D_6080 : int  := +00000;	//
	D_6081 : word := 2#0000000000000000;	//
	D_6082 : int := +00000;	//
	D_6083 : word := B#(  2,  3);	//  010271 ( 02610 )
	D_6084 : word := 2#0000000000000100;	// MB TEMP PROMEDIO
	D_6085 : real := +0.0;
	D_6086 : word := 2#0000000000000000;
	D_6087 : int  := +00001;
	D_6088 : int  := +00000;
	D_6089 : int  := +00000;
	D_6090 : word := B#(  0, 0);
	D_6091 : word := B#(000,000);
	D_6092 : word := 2#0000000000000000;
	D_6093 : int  := +00000;
	D_6094 : int  := +00000;
	D_6095 : word := B#(  1,  1);	// State (1)
	D_6096 : word := B#(  0,  1);	//
	D_6097 : word := B#(  5,  8);	//
	D_6098 : int  := +00200;	//
	D_6099 : word := 2#0000000000000000;	//
	D_6100 : word := B#(  0,  0);	//
	D_6101 : word := B#(  1,  1);	// State (2)
	D_6102 : word := B#(  0,  1);	//
	D_6103 : word := B#(  3,  4);	//
	D_6104 : int  := +00000;	//
	D_6105 : word := 2#0000000000000000;	//
	D_6106 : word := B#(  0,  0);	//
	D_6107 : word := B#(  1,  1);	// State (3)
	D_6108 : word := B#(  0,  0);	//
	D_6109 : word := B#(  0,  0);	//
	D_6110 : int  := +00000;	//
	D_6111 : word := 2#0000000000000000;	//
	D_6112 : word := B#(  0,  0);	//
	D_6113 : word := B#(  1,  1);	// State (16)
	D_6114 : word := B#(  0,  1);	//
	D_6115 : word := B#(  15,  12);	//
	D_6116 : int  := +00000;	//
	D_6117 : word := 2#0000000000000000;	//
	D_6118 : word := B#(  0,  0);	//
	D_6119 : real := 0.000000000000;	//
	D_6120 : real := 1500.000000000000;	//
	D_6121 : real := 0.000000000000;	//
	D_6122 : real := 7.500000000000;	//
	D_6123 : real := +0.0;	//
	D_6124 : int  := 00000;	//
	D_6125 : int  := 00000;	//
	D_6126 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_6127 : int  := 00000;	//
	D_6128 : int  := +00000;	//
	D_6129 : word  := B#(000,000);	//
	D_6130 : int  := +00000;	//
	D_6131 : real := 1112.000000000000;	// Limit (1)
	D_6132 : real := +0.0;	//
	D_6133 : int  := +00000;	//
	D_6134 : word := 2#0000000000000000;	//
	D_6135 : int := +00000;	//
	D_6136 : real := 1022.000000000000;	// Limit (2)
	D_6137 : real := +0.0;	//
	D_6138 : int  := +00000;	//
	D_6139 : word := 2#0000000000000000;	//
	D_6140 : int := +00000;	//
	D_6141 : word := B#(  2,  2);	//  010272 ( 02611 )
	D_6142 : word := 2#0000000000000100;	// MB PRES DIF ACEITE LUB EN FILT
	D_6143 : real := +0.0;
	D_6144 : word := 2#0000000000000000;
	D_6145 : int  := +00001;
	D_6146 : int  := +00000;
	D_6147 : int  := +00000;
	D_6148 : word := B#(  0, 0);
	D_6149 : word := B#(000,000);
	D_6150 : word := 2#0000000000000000;
	D_6151 : int  := +00000;
	D_6152 : int  := +00000;
	D_6153 : word := B#(  1,  1);	// State (1)
	D_6154 : word := B#(  0,  1);	//
	D_6155 : word := B#(  5,  8);	//
	D_6156 : int  := +00200;	//
	D_6157 : word := 2#0000000000000000;	//
	D_6158 : word := B#(  0,  0);	//
	D_6159 : word := B#(  1,  1);	// State (2)
	D_6160 : word := B#(  0,  0);	//
	D_6161 : word := B#(  0,  0);	//
	D_6162 : int  := +00000;	//
	D_6163 : word := 2#0000000000000000;	//
	D_6164 : word := B#(  0,  0);	//
	D_6165 : word := B#(  1,  1);	// State (16)
	D_6166 : word := B#(  0,  1);	//
	D_6167 : word := B#(  15,  12);	//
	D_6168 : int  := +00000;	//
	D_6169 : word := 2#0000000000000000;	//
	D_6170 : word := B#(  0,  0);	//
	D_6171 : real := -15.000000000000;	//
	D_6172 : real := 15.000000000000;	//
	D_6173 : real := 0.000000000000;	//
	D_6174 : real := 0.150000000000;	//
	D_6175 : real := +0.0;	//
	D_6176 : int  := 00000;	//
	D_6177 : int  := 00000;	//
	D_6178 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_6179 : int  := 00000;	//
	D_6180 : int  := +00000;	//
	D_6181 : word  := B#(000,000);	//
	D_6182 : int  := +00000;	//
	D_6183 : real := 10.000000000000;	// Limit (1)
	D_6184 : real := +0.0;	//
	D_6185 : int  := +00000;	//
	D_6186 : word := 2#0000000000000000;	//
	D_6187 : int := +00000;	//
	D_6188 : word := B#(  2,  2);	//  010273 ( 02612 )
	D_6189 : word := 2#0000000000000100;	// MB PRES DIF COMBUSTIBL EN FILT
	D_6190 : real := +0.0;
	D_6191 : word := 2#0000000000000000;
	D_6192 : int  := +00001;
	D_6193 : int  := +00000;
	D_6194 : int  := +00000;
	D_6195 : word := B#(  0, 0);
	D_6196 : word := B#(000,000);
	D_6197 : word := 2#0000000000000000;
	D_6198 : int  := +00000;
	D_6199 : int  := +00000;
	D_6200 : word := B#(  1,  1);	// State (1)
	D_6201 : word := B#(  0,  1);	//
	D_6202 : word := B#(  5,  8);	//
	D_6203 : int  := +00200;	//
	D_6204 : word := 2#0000000000000000;	//
	D_6205 : word := B#(  0,  0);	//
	D_6206 : word := B#(  1,  1);	// State (2)
	D_6207 : word := B#(  0,  0);	//
	D_6208 : word := B#(  0,  0);	//
	D_6209 : int  := +00000;	//
	D_6210 : word := 2#0000000000000000;	//
	D_6211 : word := B#(  0,  0);	//
	D_6212 : word := B#(  1,  1);	// State (16)
	D_6213 : word := B#(  0,  1);	//
	D_6214 : word := B#(  15,  12);	//
	D_6215 : int  := +00000;	//
	D_6216 : word := 2#0000000000000000;	//
	D_6217 : word := B#(  0,  0);	//
	D_6218 : real := -15.000000000000;	//
	D_6219 : real := 15.000000000000;	//
	D_6220 : real := 0.000000000000;	//
	D_6221 : real := 0.150000000000;	//
	D_6222 : real := +0.0;	//
	D_6223 : int  := 00000;	//
	D_6224 : int  := 00000;	//
	D_6225 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_6226 : int  := 00000;	//
	D_6227 : int  := +00000;	//
	D_6228 : word  := B#(000,000);	//
	D_6229 : int  := +00000;	//
	D_6230 : real := 10.000000000000;	// Limit (1)
	D_6231 : real := +0.0;	//
	D_6232 : int  := +00000;	//
	D_6233 : word := 2#0000000000000000;	//
	D_6234 : int := +00000;	//
	D_6235 : word := B#(  2,  2);	//  010274 ( 02613 )
	D_6236 : word := 2#0000000000000100;	// MB TEMP ACEITE CAJA ENGRANES
	D_6237 : real := +0.0;
	D_6238 : word := 2#0000000000000000;
	D_6239 : int  := +00001;
	D_6240 : int  := +00000;
	D_6241 : int  := +00000;
	D_6242 : word := B#(  0, 0);
	D_6243 : word := B#(000,000);
	D_6244 : word := 2#0000000000000000;
	D_6245 : int  := +00000;
	D_6246 : int  := +00000;
	D_6247 : word := B#(  1,  1);	// State (1)
	D_6248 : word := B#(  0,  1);	//
	D_6249 : word := B#(  5,  8);	//
	D_6250 : int  := +00200;	//
	D_6251 : word := 2#0000000000000000;	//
	D_6252 : word := B#(  0,  0);	//
	D_6253 : word := B#(  1,  1);	// State (2)
	D_6254 : word := B#(  0,  0);	//
	D_6255 : word := B#(  0,  0);	//
	D_6256 : int  := +00000;	//
	D_6257 : word := 2#0000000000000000;	//
	D_6258 : word := B#(  0,  0);	//
	D_6259 : word := B#(  1,  1);	// State (16)
	D_6260 : word := B#(  0,  1);	//
	D_6261 : word := B#(  15,  12);	//
	D_6262 : int  := +00000;	//
	D_6263 : word := 2#0000000000000000;	//
	D_6264 : word := B#(  0,  0);	//
	D_6265 : real := 0.000000000000;	//
	D_6266 : real := 300.000000000000;	//
	D_6267 : real := 0.000000000000;	//
	D_6268 : real := 1.500000000000;	//
	D_6269 : real := +0.0;	//
	D_6270 : int  := 00000;	//
	D_6271 : int  := 00000;	//
	D_6272 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_6273 : int  := 00000;	//
	D_6274 : int  := +00000;	//
	D_6275 : word  := B#(000,000);	//
	D_6276 : int  := +00000;	//
	D_6277 : real := 194.000000000000;	// Limit (1)
	D_6278 : real := +0.0;	//
	D_6279 : int  := +00000;	//
	D_6280 : word := 2#0000000000000000;	//
	D_6281 : int := +00000;	//
	D_6282 : word := B#(  2,  3);	//  040001 ( 02614 )
	D_6283 : word := 2#0000000000000100;	// TEMP COJINETE No 1 ESTRIBOR
	D_6284 : real := +0.0;
	D_6285 : word := 2#0000000000000000;
	D_6286 : int  := +00000;
	D_6287 : int  := +00000;
	D_6288 : int  := +00000;
	D_6289 : word := B#(  0, 0);
	D_6290 : word := B#(000,000);
	D_6291 : word := 2#0000000000000000;
	D_6292 : int  := +00000;
	D_6293 : int  := +00000;
	D_6294 : word := B#(  1,  1);	// State (1)
	D_6295 : word := B#(  0,  1);	//
	D_6296 : word := B#(  13,  0);	//
	D_6297 : int  := +00000;	//
	D_6298 : word := 2#0000000000000000;	//
	D_6299 : word := B#(  0,  0);	//
	D_6300 : word := B#(  1,  1);	// State (2)
	D_6301 : word := B#(  0,  1);	//
	D_6302 : word := B#(  12,  0);	//
	D_6303 : int  := +00000;	//
	D_6304 : word := 2#0000000000000000;	//
	D_6305 : word := B#(  0,  0);	//
	D_6306 : word := B#(  1,  1);	// State (3)
	D_6307 : word := B#(  0,  0);	//
	D_6308 : word := B#(  0,  0);	//
	D_6309 : int  := +00000;	//
	D_6310 : word := 2#0000000000000000;	//
	D_6311 : word := B#(  0,  0);	//
	D_6312 : word := B#(  1,  1);	// State (16)
	D_6313 : word := B#(  0,  1);	//
	D_6314 : word := B#(  15,  12);	//
	D_6315 : int  := +00000;	//
	D_6316 : word := 2#0000000000000000;	//
	D_6317 : word := B#(  0,  0);	//
	D_6318 : real := 0.049250000000;	//
	D_6319 : real := 32.000000000000;	//
	D_6320 : real := 3.940000000000;	//
	D_6321 : real := 3.940000000000;	//
	D_6322 : real := +0.0;	//
	D_6323 : int  := -0400;	//
	D_6324 : int  := 08400;	//
	D_6325 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_6326 : int  := 00000;	//
	D_6327 : int  := +00000;	//
	D_6328 : word  := B#(000,000);	//
	D_6329 : int  := +00000;	//
	D_6330 : real := 118.400000000000;	// Limit (1)
	D_6331 : real := +0.0;	//
	D_6332 : int  := +00000;	//
	D_6333 : word := 2#0000000000000000;	//
	D_6334 : int := +00000;	//
	D_6335 : real := 113.000000000000;	// Limit (2)
	D_6336 : real := +0.0;	//
	D_6337 : int  := +00000;	//
	D_6338 : word := 2#0000000000000000;	//
	D_6339 : int := +00000;	//
	D_6340 : word := B#(  2,  3);	//  040002 ( 02615 )
	D_6341 : word := 2#0000000000000100;	// TEMP COJINETE No 2 ESTRIBOR
	D_6342 : real := +0.0;
	D_6343 : word := 2#0000000000000000;
	D_6344 : int  := +00000;
	D_6345 : int  := +00000;
	D_6346 : int  := +00000;
	D_6347 : word := B#(  0, 0);
	D_6348 : word := B#(000,000);
	D_6349 : word := 2#0000000000000000;
	D_6350 : int  := +00000;
	D_6351 : int  := +00000;
	D_6352 : word := B#(  1,  1);	// State (1)
	D_6353 : word := B#(  0,  1);	//
	D_6354 : word := B#(  13,  0);	//
	D_6355 : int  := +00000;	//
	D_6356 : word := 2#0000000000000000;	//
	D_6357 : word := B#(  0,  0);	//
	D_6358 : word := B#(  1,  1);	// State (2)
	D_6359 : word := B#(  0,  1);	//
	D_6360 : word := B#(  12,  0);	//
	D_6361 : int  := +00000;	//
	D_6362 : word := 2#0000000000000000;	//
	D_6363 : word := B#(  0,  0);	//
	D_6364 : word := B#(  1,  1);	// State (3)
	D_6365 : word := B#(  0,  0);	//
	D_6366 : word := B#(  0,  0);	//
	D_6367 : int  := +00000;	//
	D_6368 : word := 2#0000000000000000;	//
	D_6369 : word := B#(  0,  0);	//
	D_6370 : word := B#(  1,  1);	// State (16)
	D_6371 : word := B#(  0,  1);	//
	D_6372 : word := B#(  15,  12);	//
	D_6373 : int  := +00000;	//
	D_6374 : word := 2#0000000000000000;	//
	D_6375 : word := B#(  0,  0);	//
	D_6376 : real := 0.049250000000;	//
	D_6377 : real := 32.000000000000;	//
	D_6378 : real := 3.940000000000;	//
	D_6379 : real := 3.940000000000;	//
	D_6380 : real := +0.0;	//
	D_6381 : int  := -0400;	//
	D_6382 : int  := 08400;	//
	D_6383 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_6384 : int  := 00000;	//
	D_6385 : int  := +00000;	//
	D_6386 : word  := B#(000,000);	//
	D_6387 : int  := +00000;	//
	D_6388 : real := 118.400000000000;	// Limit (1)
	D_6389 : real := +0.0;	//
	D_6390 : int  := +00000;	//
	D_6391 : word := 2#0000000000000000;	//
	D_6392 : int := +00000;	//
	D_6393 : real := 113.000000000000;	// Limit (2)
	D_6394 : real := +0.0;	//
	D_6395 : int  := +00000;	//
	D_6396 : word := 2#0000000000000000;	//
	D_6397 : int := +00000;	//
	D_6398 : word := B#(  2,  3);	//  040003 ( 02616 )
	D_6399 : word := 2#0000000000000100;	// TEMP COJINETE No 3 ESTRIBOR
	D_6400 : real := +0.0;
	D_6401 : word := 2#0000000000000000;
	D_6402 : int  := +00000;
	D_6403 : int  := +00000;
	D_6404 : int  := +00000;
	D_6405 : word := B#(  0, 0);
	D_6406 : word := B#(000,000);
	D_6407 : word := 2#0000000000000000;
	D_6408 : int  := +00000;
	D_6409 : int  := +00000;
	D_6410 : word := B#(  1,  1);	// State (1)
	D_6411 : word := B#(  0,  1);	//
	D_6412 : word := B#(  13,  0);	//
	D_6413 : int  := +00000;	//
	D_6414 : word := 2#0000000000000000;	//
	D_6415 : word := B#(  0,  0);	//
	D_6416 : word := B#(  1,  1);	// State (2)
	D_6417 : word := B#(  0,  1);	//
	D_6418 : word := B#(  12,  0);	//
	D_6419 : int  := +00000;	//
	D_6420 : word := 2#0000000000000000;	//
	D_6421 : word := B#(  0,  0);	//
	D_6422 : word := B#(  1,  1);	// State (3)
	D_6423 : word := B#(  0,  0);	//
	D_6424 : word := B#(  0,  0);	//
	D_6425 : int  := +00000;	//
	D_6426 : word := 2#0000000000000000;	//
	D_6427 : word := B#(  0,  0);	//
	D_6428 : word := B#(  1,  1);	// State (16)
	D_6429 : word := B#(  0,  1);	//
	D_6430 : word := B#(  15,  12);	//
	D_6431 : int  := +00000;	//
	D_6432 : word := 2#0000000000000000;	//
	D_6433 : word := B#(  0,  0);	//
	D_6434 : real := 0.049250000000;	//
	D_6435 : real := 32.000000000000;	//
	D_6436 : real := 3.940000000000;	//
	D_6437 : real := 3.940000000000;	//
	D_6438 : real := +0.0;	//
	D_6439 : int  := -0400;	//
	D_6440 : int  := 08400;	//
	D_6441 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_6442 : int  := 00000;	//
	D_6443 : int  := +00000;	//
	D_6444 : word  := B#(000,000);	//
	D_6445 : int  := +00000;	//
	D_6446 : real := 118.400000000000;	// Limit (1)
	D_6447 : real := +0.0;	//
	D_6448 : int  := +00000;	//
	D_6449 : word := 2#0000000000000000;	//
	D_6450 : int := +00000;	//
	D_6451 : real := 113.000000000000;	// Limit (2)
	D_6452 : real := +0.0;	//
	D_6453 : int  := +00000;	//
	D_6454 : word := 2#0000000000000000;	//
	D_6455 : int := +00000;	//
	D_6456 : word := B#(  2,  3);	//  040004 ( 02617 )
	D_6457 : word := 2#0000000000000100;	// TEMP COJINETE EJE DE BABOR
	D_6458 : real := +0.0;
	D_6459 : word := 2#0000000000000000;
	D_6460 : int  := +00000;
	D_6461 : int  := +00000;
	D_6462 : int  := +00000;
	D_6463 : word := B#(  0, 0);
	D_6464 : word := B#(000,000);
	D_6465 : word := 2#0000000000000000;
	D_6466 : int  := +00000;
	D_6467 : int  := +00000;
	D_6468 : word := B#(  1,  1);	// State (1)
	D_6469 : word := B#(  0,  1);	//
	D_6470 : word := B#(  13,  0);	//
	D_6471 : int  := +00000;	//
	D_6472 : word := 2#0000000000000000;	//
	D_6473 : word := B#(  0,  0);	//
	D_6474 : word := B#(  1,  1);	// State (2)
	D_6475 : word := B#(  0,  1);	//
	D_6476 : word := B#(  12,  0);	//
	D_6477 : int  := +00000;	//
	D_6478 : word := 2#0000000000000000;	//
	D_6479 : word := B#(  0,  0);	//
	D_6480 : word := B#(  1,  1);	// State (3)
	D_6481 : word := B#(  0,  0);	//
	D_6482 : word := B#(  0,  0);	//
	D_6483 : int  := +00000;	//
	D_6484 : word := 2#0000000000000000;	//
	D_6485 : word := B#(  0,  0);	//
	D_6486 : word := B#(  1,  1);	// State (16)
	D_6487 : word := B#(  0,  1);	//
	D_6488 : word := B#(  15,  12);	//
	D_6489 : int  := +00000;	//
	D_6490 : word := 2#0000000000000000;	//
	D_6491 : word := B#(  0,  0);	//
	D_6492 : real := 0.049250000000;	//
	D_6493 : real := 32.000000000000;	//
	D_6494 : real := 3.940000000000;	//
	D_6495 : real := 3.940000000000;	//
	D_6496 : real := +0.0;	//
	D_6497 : int  := -0400;	//
	D_6498 : int  := 08400;	//
	D_6499 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_6500 : int  := 00000;	//
	D_6501 : int  := +00000;	//
	D_6502 : word  := B#(000,000);	//
	D_6503 : int  := +00000;	//
	D_6504 : real := 118.400000000000;	// Limit (1)
	D_6505 : real := +0.0;	//
	D_6506 : int  := +00000;	//
	D_6507 : word := 2#0000000000000000;	//
	D_6508 : int := +00000;	//
	D_6509 : real := 113.000000000000;	// Limit (2)
	D_6510 : real := +0.0;	//
	D_6511 : int  := +00000;	//
	D_6512 : word := 2#0000000000000000;	//
	D_6513 : int := +00000;	//
	D_6514 : word := B#(  2,  6);	//  050002 ( 02618 )
	D_6515 : word := 2#0000000000000100;	// VOLTAJE BUS 1S L1-L2
	D_6516 : real := +0.0;
	D_6517 : word := 2#0000000000000000;
	D_6518 : int  := +00000;
	D_6519 : int  := +00000;
	D_6520 : int  := +00000;
	D_6521 : word := B#(  0, 0);
	D_6522 : word := B#(000,000);
	D_6523 : word := 2#0000000000000000;
	D_6524 : int  := +00000;
	D_6525 : int  := +00000;
	D_6526 : word := B#(  5,  5);	// State (1)
	D_6527 : word := B#(  0,  1);	//
	D_6528 : word := B#(  14,  0);	//
	D_6529 : int  := +00000;	//
	D_6530 : word := 2#0000000000000000;	//
	D_6531 : word := B#(  0,  0);	//
	D_6532 : word := B#(  5,  5);	// State (2)
	D_6533 : word := B#(  0,  1);	//
	D_6534 : word := B#(  13,  0);	//
	D_6535 : int  := +00000;	//
	D_6536 : word := 2#0000000000000000;	//
	D_6537 : word := B#(  0,  0);	//
	D_6538 : word := B#(  5,  5);	// State (3)
	D_6539 : word := B#(  0,  1);	//
	D_6540 : word := B#(  12,  0);	//
	D_6541 : int  := +00000;	//
	D_6542 : word := 2#0000000000000000;	//
	D_6543 : word := B#(  0,  0);	//
	D_6544 : word := B#(  5,  5);	// State (4)
	D_6545 : word := B#(  0,  0);	//
	D_6546 : word := B#(  0,  0);	//
	D_6547 : int  := +00000;	//
	D_6548 : word := 2#0000000000000000;	//
	D_6549 : word := B#(  0,  0);	//
	D_6550 : word := B#(  5,  15);	// State (5)
	D_6551 : word := B#(  0,  1);	//
	D_6552 : word := B#(  3,  5);	//
	D_6553 : int  := +00000;	//
	D_6554 : word := 2#0000000000000000;	//
	D_6555 : word := B#(  0,  0);	//
	D_6556 : word := B#(  5,  5);	// State (6)
	D_6557 : word := B#(  0,  1);	//
	D_6558 : word := B#(  8,  1);	//
	D_6559 : int  := +00000;	//
	D_6560 : word := 2#0000000000000000;	//
	D_6561 : word := B#(  0,  0);	//
	D_6562 : word := B#(  5,  5);	// State (16)
	D_6563 : word := B#(  0,  1);	//
	D_6564 : word := B#(  15,  12);	//
	D_6565 : int  := +00000;	//
	D_6566 : word := 2#0000000000000000;	//
	D_6567 : word := B#(  0,  0);	//
	D_6568 : real := 0.000000000000;	//
	D_6569 : real := 600.000000000000;	//
	D_6570 : real := 6.000000000000;	//
	D_6571 : real := 6.000000000000;	//
	D_6572 : real := +0.0;	//
	D_6573 : int  := 00000;	//
	D_6574 : int  := 00000;	//
	D_6575 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_6576 : int  := 00000;	//
	D_6577 : int  := +00000;	//
	D_6578 : word  := B#(000,000);	//
	D_6579 : int  := +00000;	//
	D_6580 : real := 480.000000000000;	// Limit (1)
	D_6581 : real := +0.0;	//
	D_6582 : int  := +00000;	//
	D_6583 : word := 2#0000000000000000;	//
	D_6584 : int := +00000;	//
	D_6585 : real := 470.000000000000;	// Limit (2)
	D_6586 : real := +0.0;	//
	D_6587 : int  := +00000;	//
	D_6588 : word := 2#0000000000000000;	//
	D_6589 : int := +00000;	//
	D_6590 : real := 460.000000000000;	// Limit (3)
	D_6591 : real := +0.0;	//
	D_6592 : int  := +00000;	//
	D_6593 : word := 2#0000000000000000;	//
	D_6594 : int := +00000;	//
	D_6595 : real := 420.000000000000;	// Limit (4)
	D_6596 : real := +0.0;	//
	D_6597 : int  := +00000;	//
	D_6598 : word := 2#0000000000000000;	//
	D_6599 : int := +00000;	//
	D_6600 : real := 400.000000000000;	// Limit (5)
	D_6601 : real := +0.0;	//
	D_6602 : int  := +00000;	//
	D_6603 : word := 2#0000000000000000;	//
	D_6604 : int := +00000;	//
	D_6605 : word := B#(  2,  6);	//  050003 ( 02619 )
	D_6606 : word := 2#0000000000000100;	// VOLTAJE BUS 1S L1-L3
	D_6607 : real := +0.0;
	D_6608 : word := 2#0000000000000000;
	D_6609 : int  := +00000;
	D_6610 : int  := +00000;
	D_6611 : int  := +00000;
	D_6612 : word := B#(  0, 0);
	D_6613 : word := B#(000,000);
	D_6614 : word := 2#0000000000000000;
	D_6615 : int  := +00000;
	D_6616 : int  := +00000;
	D_6617 : word := B#(  5,  5);	// State (1)
	D_6618 : word := B#(  0,  1);	//
	D_6619 : word := B#(  14,  0);	//
	D_6620 : int  := +00000;	//
	D_6621 : word := 2#0000000000000000;	//
	D_6622 : word := B#(  0,  0);	//
	D_6623 : word := B#(  5,  5);	// State (2)
	D_6624 : word := B#(  0,  1);	//
	D_6625 : word := B#(  13,  0);	//
	D_6626 : int  := +00000;	//
	D_6627 : word := 2#0000000000000000;	//
	D_6628 : word := B#(  0,  0);	//
	D_6629 : word := B#(  5,  5);	// State (3)
	D_6630 : word := B#(  0,  1);	//
	D_6631 : word := B#(  12,  0);	//
	D_6632 : int  := +00000;	//
	D_6633 : word := 2#0000000000000000;	//
	D_6634 : word := B#(  0,  0);	//
	D_6635 : word := B#(  5,  5);	// State (4)
	D_6636 : word := B#(  0,  0);	//
	D_6637 : word := B#(  0,  0);	//
	D_6638 : int  := +00000;	//
	D_6639 : word := 2#0000000000000000;	//
	D_6640 : word := B#(  0,  0);	//
	D_6641 : word := B#(  5,  5);	// State (5)
	D_6642 : word := B#(  0,  1);	//
	D_6643 : word := B#(  3,  5);	//
	D_6644 : int  := +00000;	//
	D_6645 : word := 2#0000000000000000;	//
	D_6646 : word := B#(  0,  0);	//
	D_6647 : word := B#(  5,  5);	// State (6)
	D_6648 : word := B#(  0,  1);	//
	D_6649 : word := B#(  8,  1);	//
	D_6650 : int  := +00000;	//
	D_6651 : word := 2#0000000000000000;	//
	D_6652 : word := B#(  0,  0);	//
	D_6653 : word := B#(  5,  5);	// State (16)
	D_6654 : word := B#(  0,  1);	//
	D_6655 : word := B#(  15,  12);	//
	D_6656 : int  := +00000;	//
	D_6657 : word := 2#0000000000000000;	//
	D_6658 : word := B#(  0,  0);	//
	D_6659 : real := 0.000000000000;	//
	D_6660 : real := 600.000000000000;	//
	D_6661 : real := 6.000000000000;	//
	D_6662 : real := 6.000000000000;	//
	D_6663 : real := +0.0;	//
	D_6664 : int  := 00000;	//
	D_6665 : int  := 00000;	//
	D_6666 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_6667 : int  := 00000;	//
	D_6668 : int  := +00000;	//
	D_6669 : word  := B#(000,000);	//
	D_6670 : int  := +00000;	//
	D_6671 : real := 480.000000000000;	// Limit (1)
	D_6672 : real := +0.0;	//
	D_6673 : int  := +00000;	//
	D_6674 : word := 2#0000000000000000;	//
	D_6675 : int := +00000;	//
	D_6676 : real := 470.000000000000;	// Limit (2)
	D_6677 : real := +0.0;	//
	D_6678 : int  := +00000;	//
	D_6679 : word := 2#0000000000000000;	//
	D_6680 : int := +00000;	//
	D_6681 : real := 460.000000000000;	// Limit (3)
	D_6682 : real := +0.0;	//
	D_6683 : int  := +00000;	//
	D_6684 : word := 2#0000000000000000;	//
	D_6685 : int := +00000;	//
	D_6686 : real := 420.000000000000;	// Limit (4)
	D_6687 : real := +0.0;	//
	D_6688 : int  := +00000;	//
	D_6689 : word := 2#0000000000000000;	//
	D_6690 : int := +00000;	//
	D_6691 : real := 400.000000000000;	// Limit (5)
	D_6692 : real := +0.0;	//
	D_6693 : int  := +00000;	//
	D_6694 : word := 2#0000000000000000;	//
	D_6695 : int := +00000;	//
	D_6696 : word := B#(  2,  6);	//  050004 ( 02620 )
	D_6697 : word := 2#0000000000000100;	// VOLTAJE BUS 1S L2-L3
	D_6698 : real := +0.0;
	D_6699 : word := 2#0000000000000000;
	D_6700 : int  := +00000;
	D_6701 : int  := +00000;
	D_6702 : int  := +00000;
	D_6703 : word := B#(  0, 0);
	D_6704 : word := B#(000,000);
	D_6705 : word := 2#0000000000000000;
	D_6706 : int  := +00000;
	D_6707 : int  := +00000;
	D_6708 : word := B#(  5,  5);	// State (1)
	D_6709 : word := B#(  0,  1);	//
	D_6710 : word := B#(  14,  0);	//
	D_6711 : int  := +00000;	//
	D_6712 : word := 2#0000000000000000;	//
	D_6713 : word := B#(  0,  0);	//
	D_6714 : word := B#(  5,  5);	// State (2)
	D_6715 : word := B#(  0,  1);	//
	D_6716 : word := B#(  13,  0);	//
	D_6717 : int  := +00000;	//
	D_6718 : word := 2#0000000000000000;	//
	D_6719 : word := B#(  0,  0);	//
	D_6720 : word := B#(  5,  5);	// State (3)
	D_6721 : word := B#(  0,  1);	//
	D_6722 : word := B#(  12,  0);	//
	D_6723 : int  := +00000;	//
	D_6724 : word := 2#0000000000000000;	//
	D_6725 : word := B#(  0,  0);	//
	D_6726 : word := B#(  5,  5);	// State (4)
	D_6727 : word := B#(  0,  0);	//
	D_6728 : word := B#(  0,  0);	//
	D_6729 : int  := +00000;	//
	D_6730 : word := 2#0000000000000000;	//
	D_6731 : word := B#(  0,  0);	//
	D_6732 : word := B#(  5,  5);	// State (5)
	D_6733 : word := B#(  0,  1);	//
	D_6734 : word := B#(  3,  5);	//
	D_6735 : int  := +00000;	//
	D_6736 : word := 2#0000000000000000;	//
	D_6737 : word := B#(  0,  0);	//
	D_6738 : word := B#(  5,  5);	// State (6)
	D_6739 : word := B#(  0,  1);	//
	D_6740 : word := B#(  8,  1);	//
	D_6741 : int  := +00000;	//
	D_6742 : word := 2#0000000000000000;	//
	D_6743 : word := B#(  0,  0);	//
	D_6744 : word := B#(  5,  5);	// State (16)
	D_6745 : word := B#(  0,  1);	//
	D_6746 : word := B#(  15,  12);	//
	D_6747 : int  := +00000;	//
	D_6748 : word := 2#0000000000000000;	//
	D_6749 : word := B#(  0,  0);	//
	D_6750 : real := 0.000000000000;	//
	D_6751 : real := 600.000000000000;	//
	D_6752 : real := 6.000000000000;	//
	D_6753 : real := 6.000000000000;	//
	D_6754 : real := +0.0;	//
	D_6755 : int  := 00000;	//
	D_6756 : int  := 00000;	//
	D_6757 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_6758 : int  := 00000;	//
	D_6759 : int  := +00000;	//
	D_6760 : word  := B#(000,000);	//
	D_6761 : int  := +00000;	//
	D_6762 : real := 480.000000000000;	// Limit (1)
	D_6763 : real := +0.0;	//
	D_6764 : int  := +00000;	//
	D_6765 : word := 2#0000000000000000;	//
	D_6766 : int := +00000;	//
	D_6767 : real := 470.000000000000;	// Limit (2)
	D_6768 : real := +0.0;	//
	D_6769 : int  := +00000;	//
	D_6770 : word := 2#0000000000000000;	//
	D_6771 : int := +00000;	//
	D_6772 : real := 460.000000000000;	// Limit (3)
	D_6773 : real := +0.0;	//
	D_6774 : int  := +00000;	//
	D_6775 : word := 2#0000000000000000;	//
	D_6776 : int := +00000;	//
	D_6777 : real := 420.000000000000;	// Limit (4)
	D_6778 : real := +0.0;	//
	D_6779 : int  := +00000;	//
	D_6780 : word := 2#0000000000000000;	//
	D_6781 : int := +00000;	//
	D_6782 : real := 400.000000000000;	// Limit (5)
	D_6783 : real := +0.0;	//
	D_6784 : int  := +00000;	//
	D_6785 : word := 2#0000000000000000;	//
	D_6786 : int := +00000;	//
	D_6787 : word := B#(  2,  6);	//  050005 ( 02621 )
	D_6788 : word := 2#0000000000000100;	// VOLTAJE BUS 2S L1-L2
	D_6789 : real := +0.0;
	D_6790 : word := 2#0000000000000000;
	D_6791 : int  := +00000;
	D_6792 : int  := +00000;
	D_6793 : int  := +00000;
	D_6794 : word := B#(  0, 0);
	D_6795 : word := B#(000,000);
	D_6796 : word := 2#0000000000000000;
	D_6797 : int  := +00000;
	D_6798 : int  := +00000;
	D_6799 : word := B#(  5,  5);	// State (1)
	D_6800 : word := B#(  0,  1);	//
	D_6801 : word := B#(  14,  0);	//
	D_6802 : int  := +00000;	//
	D_6803 : word := 2#0000000000000000;	//
	D_6804 : word := B#(  0,  0);	//
	D_6805 : word := B#(  5,  5);	// State (2)
	D_6806 : word := B#(  0,  1);	//
	D_6807 : word := B#(  13,  0);	//
	D_6808 : int  := +00000;	//
	D_6809 : word := 2#0000000000000000;	//
	D_6810 : word := B#(  0,  0);	//
	D_6811 : word := B#(  5,  5);	// State (3)
	D_6812 : word := B#(  0,  1);	//
	D_6813 : word := B#(  12,  0);	//
	D_6814 : int  := +00000;	//
	D_6815 : word := 2#0000000000000000;	//
	D_6816 : word := B#(  0,  0);	//
	D_6817 : word := B#(  5,  5);	// State (4)
	D_6818 : word := B#(  0,  0);	//
	D_6819 : word := B#(  0,  0);	//
	D_6820 : int  := +00000;	//
	D_6821 : word := 2#0000000000000000;	//
	D_6822 : word := B#(  0,  0);	//
	D_6823 : word := B#(  5,  5);	// State (5)
	D_6824 : word := B#(  0,  1);	//
	D_6825 : word := B#(  3,  5);	//
	D_6826 : int  := +00000;	//
	D_6827 : word := 2#0000000000000000;	//
	D_6828 : word := B#(  0,  0);	//
	D_6829 : word := B#(  5,  5);	// State (6)
	D_6830 : word := B#(  0,  1);	//
	D_6831 : word := B#(  8,  1);	//
	D_6832 : int  := +00000;	//
	D_6833 : word := 2#0000000000000000;	//
	D_6834 : word := B#(  0,  0);	//
	D_6835 : word := B#(  5,  5);	// State (16)
	D_6836 : word := B#(  0,  1);	//
	D_6837 : word := B#(  15,  12);	//
	D_6838 : int  := +00000;	//
	D_6839 : word := 2#0000000000000000;	//
	D_6840 : word := B#(  0,  0);	//
	D_6841 : real := 0.000000000000;	//
	D_6842 : real := 600.000000000000;	//
	D_6843 : real := 6.000000000000;	//
	D_6844 : real := 6.000000000000;	//
	D_6845 : real := +0.0;	//
	D_6846 : int  := 00000;	//
	D_6847 : int  := 00000;	//
	D_6848 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_6849 : int  := 00000;	//
	D_6850 : int  := +00000;	//
	D_6851 : word  := B#(000,000);	//
	D_6852 : int  := +00000;	//
	D_6853 : real := 480.000000000000;	// Limit (1)
	D_6854 : real := +0.0;	//
	D_6855 : int  := +00000;	//
	D_6856 : word := 2#0000000000000000;	//
	D_6857 : int := +00000;	//
	D_6858 : real := 470.000000000000;	// Limit (2)
	D_6859 : real := +0.0;	//
	D_6860 : int  := +00000;	//
	D_6861 : word := 2#0000000000000000;	//
	D_6862 : int := +00000;	//
	D_6863 : real := 460.000000000000;	// Limit (3)
	D_6864 : real := +0.0;	//
	D_6865 : int  := +00000;	//
	D_6866 : word := 2#0000000000000000;	//
	D_6867 : int := +00000;	//
	D_6868 : real := 420.000000000000;	// Limit (4)
	D_6869 : real := +0.0;	//
	D_6870 : int  := +00000;	//
	D_6871 : word := 2#0000000000000000;	//
	D_6872 : int := +00000;	//
	D_6873 : real := 400.000000000000;	// Limit (5)
	D_6874 : real := +0.0;	//
	D_6875 : int  := +00000;	//
	D_6876 : word := 2#0000000000000000;	//
	D_6877 : int := +00000;	//
	D_6878 : word := B#(  2,  6);	//  050006 ( 02622 )
	D_6879 : word := 2#0000000000000100;	// VOLTAJE BUS 2S L1-L3
	D_6880 : real := +0.0;
	D_6881 : word := 2#0000000000000000;
	D_6882 : int  := +00000;
	D_6883 : int  := +00000;
	D_6884 : int  := +00000;
	D_6885 : word := B#(  0, 0);
	D_6886 : word := B#(000,000);
	D_6887 : word := 2#0000000000000000;
	D_6888 : int  := +00000;
	D_6889 : int  := +00000;
	D_6890 : word := B#(  5,  5);	// State (1)
	D_6891 : word := B#(  0,  1);	//
	D_6892 : word := B#(  14,  0);	//
	D_6893 : int  := +00000;	//
	D_6894 : word := 2#0000000000000000;	//
	D_6895 : word := B#(  0,  0);	//
	D_6896 : word := B#(  5,  5);	// State (2)
	D_6897 : word := B#(  0,  1);	//
	D_6898 : word := B#(  13,  0);	//
	D_6899 : int  := +00000;	//
	D_6900 : word := 2#0000000000000000;	//
	D_6901 : word := B#(  0,  0);	//
	D_6902 : word := B#(  5,  5);	// State (3)
	D_6903 : word := B#(  0,  1);	//
	D_6904 : word := B#(  12,  0);	//
	D_6905 : int  := +00000;	//
	D_6906 : word := 2#0000000000000000;	//
	D_6907 : word := B#(  0,  0);	//
	D_6908 : word := B#(  5,  5);	// State (4)
	D_6909 : word := B#(  0,  0);	//
	D_6910 : word := B#(  0,  0);	//
	D_6911 : int  := +00000;	//
	D_6912 : word := 2#0000000000000000;	//
	D_6913 : word := B#(  0,  0);	//
	D_6914 : word := B#(  10,  10);	// State (5)
	D_6915 : word := B#(  0,  1);	//
	D_6916 : word := B#(  3,  5);	//
	D_6917 : int  := +00000;	//
	D_6918 : word := 2#0000000000000000;	//
	D_6919 : word := B#(  0,  0);	//
	D_6920 : word := B#(  10,  10);	// State (6)
	D_6921 : word := B#(  0,  1);	//
	D_6922 : word := B#(  8,  1);	//
	D_6923 : int  := +00000;	//
	D_6924 : word := 2#0000000000000000;	//
	D_6925 : word := B#(  0,  0);	//
	D_6926 : word := B#(  5,  5);	// State (16)
	D_6927 : word := B#(  0,  1);	//
	D_6928 : word := B#(  15,  12);	//
	D_6929 : int  := +00000;	//
	D_6930 : word := 2#0000000000000000;	//
	D_6931 : word := B#(  0,  0);	//
	D_6932 : real := 0.000000000000;	//
	D_6933 : real := 600.000000000000;	//
	D_6934 : real := 6.000000000000;	//
	D_6935 : real := 6.000000000000;	//
	D_6936 : real := +0.0;	//
	D_6937 : int  := 00000;	//
	D_6938 : int  := 00000;	//
	D_6939 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_6940 : int  := 00000;	//
	D_6941 : int  := +00000;	//
	D_6942 : word  := B#(000,000);	//
	D_6943 : int  := +00000;	//
	D_6944 : real := 480.000000000000;	// Limit (1)
	D_6945 : real := +0.0;	//
	D_6946 : int  := +00000;	//
	D_6947 : word := 2#0000000000000000;	//
	D_6948 : int := +00000;	//
	D_6949 : real := 470.000000000000;	// Limit (2)
	D_6950 : real := +0.0;	//
	D_6951 : int  := +00000;	//
	D_6952 : word := 2#0000000000000000;	//
	D_6953 : int := +00000;	//
	D_6954 : real := 460.000000000000;	// Limit (3)
	D_6955 : real := +0.0;	//
	D_6956 : int  := +00000;	//
	D_6957 : word := 2#0000000000000000;	//
	D_6958 : int := +00000;	//
	D_6959 : real := 420.000000000000;	// Limit (4)
	D_6960 : real := +0.0;	//
	D_6961 : int  := +00000;	//
	D_6962 : word := 2#0000000000000000;	//
	D_6963 : int := +00000;	//
	D_6964 : real := 400.000000000000;	// Limit (5)
	D_6965 : real := +0.0;	//
	D_6966 : int  := +00000;	//
	D_6967 : word := 2#0000000000000000;	//
	D_6968 : int := +00000;	//
	D_6969 : word := B#(  2,  6);	//  050007 ( 02623 )
	D_6970 : word := 2#0000000000000100;	// VOLTAJE BUS 2S L2-L3
	D_6971 : real := +0.0;
	D_6972 : word := 2#0000000000000000;
	D_6973 : int  := +00000;
	D_6974 : int  := +00000;
	D_6975 : int  := +00000;
	D_6976 : word := B#(  0, 0);
	D_6977 : word := B#(000,000);
	D_6978 : word := 2#0000000000000000;
	D_6979 : int  := +00000;
	D_6980 : int  := +00000;
	D_6981 : word := B#(  5,  5);	// State (1)
	D_6982 : word := B#(  0,  1);	//
	D_6983 : word := B#(  14,  0);	//
	D_6984 : int  := +00000;	//
	D_6985 : word := 2#0000000000000000;	//
	D_6986 : word := B#(  0,  0);	//
	D_6987 : word := B#(  5,  5);	// State (2)
	D_6988 : word := B#(  0,  1);	//
	D_6989 : word := B#(  13,  0);	//
	D_6990 : int  := +00000;	//
	D_6991 : word := 2#0000000000000000;	//
	D_6992 : word := B#(  0,  0);	//
	D_6993 : word := B#(  5,  5);	// State (3)
	D_6994 : word := B#(  0,  1);	//
	D_6995 : word := B#(  12,  0);	//
	D_6996 : int  := +00000;	//
	D_6997 : word := 2#0000000000000000;	//
	D_6998 : word := B#(  0,  0);	//
	D_6999 : word := B#(  5,  5);	// State (4)
	D_7000 : word := B#(  0,  0);	//
	D_7001 : word := B#(  0,  0);	//
	D_7002 : int  := +00000;	//
	D_7003 : word := 2#0000000000000000;	//
	D_7004 : word := B#(  0,  0);	//
	D_7005 : word := B#(  10,  10);	// State (5)
	D_7006 : word := B#(  0,  1);	//
	D_7007 : word := B#(  3,  5);	//
	D_7008 : int  := +00000;	//
	D_7009 : word := 2#0000000000000000;	//
	D_7010 : word := B#(  0,  0);	//
	D_7011 : word := B#(  10,  10);	// State (6)
	D_7012 : word := B#(  0,  1);	//
	D_7013 : word := B#(  8,  1);	//
	D_7014 : int  := +00000;	//
	D_7015 : word := 2#0000000000000000;	//
	D_7016 : word := B#(  0,  0);	//
	D_7017 : word := B#(  5,  5);	// State (16)
	D_7018 : word := B#(  0,  1);	//
	D_7019 : word := B#(  15,  12);	//
	D_7020 : int  := +00000;	//
	D_7021 : word := 2#0000000000000000;	//
	D_7022 : word := B#(  0,  0);	//
	D_7023 : real := 0.000000000000;	//
	D_7024 : real := 600.000000000000;	//
	D_7025 : real := 6.000000000000;	//
	D_7026 : real := 6.000000000000;	//
	D_7027 : real := +0.0;	//
	D_7028 : int  := 00000;	//
	D_7029 : int  := 00000;	//
	D_7030 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_7031 : int  := 00000;	//
	D_7032 : int  := +00000;	//
	D_7033 : word  := B#(000,000);	//
	D_7034 : int  := +00000;	//
	D_7035 : real := 480.000000000000;	// Limit (1)
	D_7036 : real := +0.0;	//
	D_7037 : int  := +00000;	//
	D_7038 : word := 2#0000000000000000;	//
	D_7039 : int := +00000;	//
	D_7040 : real := 470.000000000000;	// Limit (2)
	D_7041 : real := +0.0;	//
	D_7042 : int  := +00000;	//
	D_7043 : word := 2#0000000000000000;	//
	D_7044 : int := +00000;	//
	D_7045 : real := 460.000000000000;	// Limit (3)
	D_7046 : real := +0.0;	//
	D_7047 : int  := +00000;	//
	D_7048 : word := 2#0000000000000000;	//
	D_7049 : int := +00000;	//
	D_7050 : real := 420.000000000000;	// Limit (4)
	D_7051 : real := +0.0;	//
	D_7052 : int  := +00000;	//
	D_7053 : word := 2#0000000000000000;	//
	D_7054 : int := +00000;	//
	D_7055 : real := 400.000000000000;	// Limit (5)
	D_7056 : real := +0.0;	//
	D_7057 : int  := +00000;	//
	D_7058 : word := 2#0000000000000000;	//
	D_7059 : int := +00000;	//
	D_7060 : word := B#(  2,  5);	//  050008 ( 02624 )
	D_7061 : word := 2#0000000000000100;	// FRECUENCIA BUS 1S
	D_7062 : real := +0.0;
	D_7063 : word := 2#0000000000000000;
	D_7064 : int  := +00028;
	D_7065 : int  := +00000;
	D_7066 : int  := +00000;
	D_7067 : word := B#(  0, 0);
	D_7068 : word := B#(000,000);
	D_7069 : word := 2#0000000000000000;
	D_7070 : int  := +00000;
	D_7071 : int  := +00000;
	D_7072 : word := B#(  5,  5);	// State (1)
	D_7073 : word := B#(  0,  1);	//
	D_7074 : word := B#(  13,  0);	//
	D_7075 : int  := +00000;	//
	D_7076 : word := 2#0000000000000000;	//
	D_7077 : word := B#(  0,  0);	//
	D_7078 : word := B#(  5,  5);	// State (2)
	D_7079 : word := B#(  0,  0);	//
	D_7080 : word := B#(  0,  0);	//
	D_7081 : int  := +00000;	//
	D_7082 : word := 2#0000000000000000;	//
	D_7083 : word := B#(  0,  0);	//
	D_7084 : word := B#(  10,  10);	// State (3)
	D_7085 : word := B#(  0,  1);	//
	D_7086 : word := B#(  6,  1);	//
	D_7087 : int  := +00198;	//
	D_7088 : word := 2#0000000000000000;	//
	D_7089 : word := B#(  0,  0);	//
	D_7090 : word := B#(  10,  10);	// State (4)
	D_7091 : word := B#(  0,  1);	//
	D_7092 : word := B#(  7,  1);	//
	D_7093 : int  := +00198;	//
	D_7094 : word := 2#0000000000000000;	//
	D_7095 : word := B#(  0,  0);	//
	D_7096 : word := B#(  10,  10);	// State (5)
	D_7097 : word := B#(  0,  1);	//
	D_7098 : word := B#(  8,  1);	//
	D_7099 : int  := +00198;	//
	D_7100 : word := 2#0000000000000000;	//
	D_7101 : word := B#(  0,  0);	//
	D_7102 : word := B#(  5,  5);	// State (16)
	D_7103 : word := B#(  0,  1);	//
	D_7104 : word := B#(  15,  12);	//
	D_7105 : int  := +00000;	//
	D_7106 : word := 2#0000000000000000;	//
	D_7107 : word := B#(  0,  0);	//
	D_7108 : real := 0.000000000000;	//
	D_7109 : real := 65.000000000000;	//
	D_7110 : real := 0.325000000000;	//
	D_7111 : real := 0.650000000000;	//
	D_7112 : real := +0.0;	//
	D_7113 : int  := 00000;	//
	D_7114 : int  := 00000;	//
	D_7115 : word  := B#(001,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_7116 : int  := 00000;	//
	D_7117 : int  := +00000;	//
	D_7118 : word  := B#(000,000);	//
	D_7119 : int  := +00000;	//
	D_7120 : real := 62.500000000000;	// Limit (1)
	D_7121 : real := +0.0;	//
	D_7122 : int  := +00000;	//
	D_7123 : word := 2#0000000000000000;	//
	D_7124 : int := +00000;	//
	D_7125 : real := 57.500000000000;	// Limit (2)
	D_7126 : real := +0.0;	//
	D_7127 : int  := +00000;	//
	D_7128 : word := 2#0000000000000000;	//
	D_7129 : int := +00000;	//
	D_7130 : real := 56.000000000000;	// Limit (3)
	D_7131 : real := +0.0;	//
	D_7132 : int  := +00000;	//
	D_7133 : word := 2#0000000000000000;	//
	D_7134 : int := +00000;	//
	D_7135 : real := 55.000000000000;	// Limit (4)
	D_7136 : real := +0.0;	//
	D_7137 : int  := +00000;	//
	D_7138 : word := 2#0000000000000000;	//
	D_7139 : int := +00000;	//
	D_7140 : word := B#(  2,  5);	//  050009 ( 02625 )
	D_7141 : word := 2#0000000000000100;	// FRECUENCIA BUS 2S
	D_7142 : real := +0.0;
	D_7143 : word := 2#0000000000000000;
	D_7144 : int  := +00028;
	D_7145 : int  := +00000;
	D_7146 : int  := +00000;
	D_7147 : word := B#(  0, 0);
	D_7148 : word := B#(000,000);
	D_7149 : word := 2#0000000000000000;
	D_7150 : int  := +00000;
	D_7151 : int  := +00000;
	D_7152 : word := B#(  5,  5);	// State (1)
	D_7153 : word := B#(  0,  1);	//
	D_7154 : word := B#(  13,  0);	//
	D_7155 : int  := +00000;	//
	D_7156 : word := 2#0000000000000000;	//
	D_7157 : word := B#(  0,  0);	//
	D_7158 : word := B#(  5,  5);	// State (2)
	D_7159 : word := B#(  0,  0);	//
	D_7160 : word := B#(  0,  0);	//
	D_7161 : int  := +00000;	//
	D_7162 : word := 2#0000000000000000;	//
	D_7163 : word := B#(  0,  0);	//
	D_7164 : word := B#(  10,  10);	// State (3)
	D_7165 : word := B#(  0,  1);	//
	D_7166 : word := B#(  6,  1);	//
	D_7167 : int  := +00198;	//
	D_7168 : word := 2#0000000000000000;	//
	D_7169 : word := B#(  0,  0);	//
	D_7170 : word := B#(  10,  10);	// State (4)
	D_7171 : word := B#(  0,  1);	//
	D_7172 : word := B#(  7,  1);	//
	D_7173 : int  := +00198;	//
	D_7174 : word := 2#0000000000000000;	//
	D_7175 : word := B#(  0,  0);	//
	D_7176 : word := B#(  10,  10);	// State (5)
	D_7177 : word := B#(  0,  1);	//
	D_7178 : word := B#(  8,  1);	//
	D_7179 : int  := +00198;	//
	D_7180 : word := 2#0000000000000000;	//
	D_7181 : word := B#(  0,  0);	//
	D_7182 : word := B#(  5,  5);	// State (16)
	D_7183 : word := B#(  0,  1);	//
	D_7184 : word := B#(  15,  12);	//
	D_7185 : int  := +00000;	//
	D_7186 : word := 2#0000000000000000;	//
	D_7187 : word := B#(  0,  0);	//
	D_7188 : real := 0.000000000000;	//
	D_7189 : real := 65.000000000000;	//
	D_7190 : real := 0.325000000000;	//
	D_7191 : real := 0.650000000000;	//
	D_7192 : real := +0.0;	//
	D_7193 : int  := 00000;	//
	D_7194 : int  := 00000;	//
	D_7195 : word  := B#(001,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_7196 : int  := 00000;	//
	D_7197 : int  := +00000;	//
	D_7198 : word  := B#(000,000);	//
	D_7199 : int  := +00000;	//
	D_7200 : real := 62.500000000000;	// Limit (1)
	D_7201 : real := +0.0;	//
	D_7202 : int  := +00000;	//
	D_7203 : word := 2#0000000000000000;	//
	D_7204 : int := +00000;	//
	D_7205 : real := 57.500000000000;	// Limit (2)
	D_7206 : real := +0.0;	//
	D_7207 : int  := +00000;	//
	D_7208 : word := 2#0000000000000000;	//
	D_7209 : int := +00000;	//
	D_7210 : real := 56.000000000000;	// Limit (3)
	D_7211 : real := +0.0;	//
	D_7212 : int  := +00000;	//
	D_7213 : word := 2#0000000000000000;	//
	D_7214 : int := +00000;	//
	D_7215 : real := 55.000000000000;	// Limit (4)
	D_7216 : real := +0.0;	//
	D_7217 : int  := +00000;	//
	D_7218 : word := 2#0000000000000000;	//
	D_7219 : int := +00000;	//
	D_7220 : word := B#(  2,  6);	//  050101 ( 02626 )
	D_7221 : word := 2#0000000000000100;	// GEN 1 VOLTAJE L1-L2
	D_7222 : real := +0.0;
	D_7223 : word := 2#0000000000000000;
	D_7224 : int  := +00048;
	D_7225 : int  := +00000;
	D_7226 : int  := +00000;
	D_7227 : word := B#(  0, 0);
	D_7228 : word := B#(000,000);
	D_7229 : word := 2#0000000000000000;
	D_7230 : int  := +00000;
	D_7231 : int  := +00000;
	D_7232 : word := B#(  5,  5);	// State (1)
	D_7233 : word := B#(  0,  1);	//
	D_7234 : word := B#(  14,  0);	//
	D_7235 : int  := +00000;	//
	D_7236 : word := 2#0000000000000000;	//
	D_7237 : word := B#(  0,  0);	//
	D_7238 : word := B#(  5,  5);	// State (2)
	D_7239 : word := B#(  0,  1);	//
	D_7240 : word := B#(  13,  0);	//
	D_7241 : int  := +00000;	//
	D_7242 : word := 2#0000000000000000;	//
	D_7243 : word := B#(  0,  0);	//
	D_7244 : word := B#(  5,  5);	// State (3)
	D_7245 : word := B#(  0,  1);	//
	D_7246 : word := B#(  12,  0);	//
	D_7247 : int  := +00000;	//
	D_7248 : word := 2#0000000000000000;	//
	D_7249 : word := B#(  0,  0);	//
	D_7250 : word := B#(  5,  5);	// State (4)
	D_7251 : word := B#(  0,  0);	//
	D_7252 : word := B#(  0,  0);	//
	D_7253 : int  := +00000;	//
	D_7254 : word := 2#0000000000000000;	//
	D_7255 : word := B#(  0,  0);	//
	D_7256 : word := B#(  10,  10);	// State (5)
	D_7257 : word := B#(  0,  1);	//
	D_7258 : word := B#(  3,  5);	//
	D_7259 : int  := +00202;	//
	D_7260 : word := 2#0000000000000000;	//
	D_7261 : word := B#(  0,  0);	//
	D_7262 : word := B#(  10,  10);	// State (6)
	D_7263 : word := B#(  0,  1);	//
	D_7264 : word := B#(  8,  1);	//
	D_7265 : int  := +00202;	//
	D_7266 : word := 2#0000000000000000;	//
	D_7267 : word := B#(  0,  0);	//
	D_7268 : word := B#(  5,  5);	// State (16)
	D_7269 : word := B#(  0,  1);	//
	D_7270 : word := B#(  15,  12);	//
	D_7271 : int  := +00202;	//
	D_7272 : word := 2#0000000000000000;	//
	D_7273 : word := B#(  0,  0);	//
	D_7274 : real := 0.000000000000;	//
	D_7275 : real := 600.000000000000;	//
	D_7276 : real := 6.000000000000;	//
	D_7277 : real := 6.000000000000;	//
	D_7278 : real := +0.0;	//
	D_7279 : int  := 00000;	//
	D_7280 : int  := 00000;	//
	D_7281 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_7282 : int  := 00000;	//
	D_7283 : int  := +00000;	//
	D_7284 : word  := B#(000,000);	//
	D_7285 : int  := +00000;	//
	D_7286 : real := 480.000000000000;	// Limit (1)
	D_7287 : real := +0.0;	//
	D_7288 : int  := +00000;	//
	D_7289 : word := 2#0000000000000000;	//
	D_7290 : int := +00000;	//
	D_7291 : real := 470.000000000000;	// Limit (2)
	D_7292 : real := +0.0;	//
	D_7293 : int  := +00000;	//
	D_7294 : word := 2#0000000000000000;	//
	D_7295 : int := +00000;	//
	D_7296 : real := 460.000000000000;	// Limit (3)
	D_7297 : real := +0.0;	//
	D_7298 : int  := +00000;	//
	D_7299 : word := 2#0000000000000000;	//
	D_7300 : int := +00000;	//
	D_7301 : real := 420.000000000000;	// Limit (4)
	D_7302 : real := +0.0;	//
	D_7303 : int  := +00000;	//
	D_7304 : word := 2#0000000000000000;	//
	D_7305 : int := +00000;	//
	D_7306 : real := 400.000000000000;	// Limit (5)
	D_7307 : real := +0.0;	//
	D_7308 : int  := +00000;	//
	D_7309 : word := 2#0000000000000000;	//
	D_7310 : int := +00000;	//
	D_7311 : word := B#(  2,  6);	//  050102 ( 02627 )
	D_7312 : word := 2#0000000000000100;	// GEN 1 VOLTAJE L1-L3
	D_7313 : real := +0.0;
	D_7314 : word := 2#0000000000000000;
	D_7315 : int  := +00048;
	D_7316 : int  := +00000;
	D_7317 : int  := +00000;
	D_7318 : word := B#(  0, 0);
	D_7319 : word := B#(000,000);
	D_7320 : word := 2#0000000000000000;
	D_7321 : int  := +00000;
	D_7322 : int  := +00000;
	D_7323 : word := B#(  5,  5);	// State (1)
	D_7324 : word := B#(  0,  1);	//
	D_7325 : word := B#(  14,  0);	//
	D_7326 : int  := +00000;	//
	D_7327 : word := 2#0000000000000000;	//
	D_7328 : word := B#(  0,  0);	//
	D_7329 : word := B#(  5,  5);	// State (2)
	D_7330 : word := B#(  0,  1);	//
	D_7331 : word := B#(  13,  0);	//
	D_7332 : int  := +00000;	//
	D_7333 : word := 2#0000000000000000;	//
	D_7334 : word := B#(  0,  0);	//
	D_7335 : word := B#(  5,  5);	// State (3)
	D_7336 : word := B#(  0,  1);	//
	D_7337 : word := B#(  12,  0);	//
	D_7338 : int  := +00000;	//
	D_7339 : word := 2#0000000000000000;	//
	D_7340 : word := B#(  0,  0);	//
	D_7341 : word := B#(  5,  5);	// State (4)
	D_7342 : word := B#(  0,  0);	//
	D_7343 : word := B#(  0,  0);	//
	D_7344 : int  := +00000;	//
	D_7345 : word := 2#0000000000000000;	//
	D_7346 : word := B#(  0,  0);	//
	D_7347 : word := B#(  10,  10);	// State (5)
	D_7348 : word := B#(  0,  1);	//
	D_7349 : word := B#(  3,  5);	//
	D_7350 : int  := +00202;	//
	D_7351 : word := 2#0000000000000000;	//
	D_7352 : word := B#(  0,  0);	//
	D_7353 : word := B#(  10,  10);	// State (6)
	D_7354 : word := B#(  0,  1);	//
	D_7355 : word := B#(  8,  1);	//
	D_7356 : int  := +00202;	//
	D_7357 : word := 2#0000000000000000;	//
	D_7358 : word := B#(  0,  0);	//
	D_7359 : word := B#(  5,  5);	// State (16)
	D_7360 : word := B#(  0,  1);	//
	D_7361 : word := B#(  15,  12);	//
	D_7362 : int  := +00202;	//
	D_7363 : word := 2#0000000000000000;	//
	D_7364 : word := B#(  0,  0);	//
	D_7365 : real := 0.000000000000;	//
	D_7366 : real := 600.000000000000;	//
	D_7367 : real := 6.000000000000;	//
	D_7368 : real := 6.000000000000;	//
	D_7369 : real := +0.0;	//
	D_7370 : int  := 00000;	//
	D_7371 : int  := 00000;	//
	D_7372 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_7373 : int  := 00000;	//
	D_7374 : int  := +00000;	//
	D_7375 : word  := B#(000,000);	//
	D_7376 : int  := +00000;	//
	D_7377 : real := 480.000000000000;	// Limit (1)
	D_7378 : real := +0.0;	//
	D_7379 : int  := +00000;	//
	D_7380 : word := 2#0000000000000000;	//
	D_7381 : int := +00000;	//
	D_7382 : real := 470.000000000000;	// Limit (2)
	D_7383 : real := +0.0;	//
	D_7384 : int  := +00000;	//
	D_7385 : word := 2#0000000000000000;	//
	D_7386 : int := +00000;	//
	D_7387 : real := 460.000000000000;	// Limit (3)
	D_7388 : real := +0.0;	//
	D_7389 : int  := +00000;	//
	D_7390 : word := 2#0000000000000000;	//
	D_7391 : int := +00000;	//
	D_7392 : real := 420.000000000000;	// Limit (4)
	D_7393 : real := +0.0;	//
	D_7394 : int  := +00000;	//
	D_7395 : word := 2#0000000000000000;	//
	D_7396 : int := +00000;	//
	D_7397 : real := 400.000000000000;	// Limit (5)
	D_7398 : real := +0.0;	//
	D_7399 : int  := +00000;	//
	D_7400 : word := 2#0000000000000000;	//
	D_7401 : int := +00000;	//
	D_7402 : word := B#(  2,  6);	//  050103 ( 02628 )
	D_7403 : word := 2#0000000000000100;	// GEN 1 VOLTAJE L2-L3
	D_7404 : real := +0.0;
	D_7405 : word := 2#0000000000000000;
	D_7406 : int  := +00048;
	D_7407 : int  := +00000;
	D_7408 : int  := +00000;
	D_7409 : word := B#(  0, 0);
	D_7410 : word := B#(000,000);
	D_7411 : word := 2#0000000000000000;
	D_7412 : int  := +00000;
	D_7413 : int  := +00000;
	D_7414 : word := B#(  5,  5);	// State (1)
	D_7415 : word := B#(  0,  1);	//
	D_7416 : word := B#(  14,  0);	//
	D_7417 : int  := +00000;	//
	D_7418 : word := 2#0000000000000000;	//
	D_7419 : word := B#(  0,  0);	//
	D_7420 : word := B#(  5,  5);	// State (2)
	D_7421 : word := B#(  0,  1);	//
	D_7422 : word := B#(  13,  0);	//
	D_7423 : int  := +00000;	//
	D_7424 : word := 2#0000000000000000;	//
	D_7425 : word := B#(  0,  0);	//
	D_7426 : word := B#(  5,  5);	// State (3)
	D_7427 : word := B#(  0,  1);	//
	D_7428 : word := B#(  12,  0);	//
	D_7429 : int  := +00000;	//
	D_7430 : word := 2#0000000000000000;	//
	D_7431 : word := B#(  0,  0);	//
	D_7432 : word := B#(  5,  5);	// State (4)
	D_7433 : word := B#(  0,  0);	//
	D_7434 : word := B#(  0,  0);	//
	D_7435 : int  := +00000;	//
	D_7436 : word := 2#0000000000000000;	//
	D_7437 : word := B#(  0,  0);	//
	D_7438 : word := B#(  10,  10);	// State (5)
	D_7439 : word := B#(  0,  1);	//
	D_7440 : word := B#(  3,  5);	//
	D_7441 : int  := +00202;	//
	D_7442 : word := 2#0000000000000000;	//
	D_7443 : word := B#(  0,  0);	//
	D_7444 : word := B#(  10,  10);	// State (6)
	D_7445 : word := B#(  0,  1);	//
	D_7446 : word := B#(  8,  1);	//
	D_7447 : int  := +00202;	//
	D_7448 : word := 2#0000000000000000;	//
	D_7449 : word := B#(  0,  0);	//
	D_7450 : word := B#(  5,  5);	// State (16)
	D_7451 : word := B#(  0,  1);	//
	D_7452 : word := B#(  15,  12);	//
	D_7453 : int  := +00202;	//
	D_7454 : word := 2#0000000000000000;	//
	D_7455 : word := B#(  0,  0);	//
	D_7456 : real := 0.000000000000;	//
	D_7457 : real := 600.000000000000;	//
	D_7458 : real := 6.000000000000;	//
	D_7459 : real := 6.000000000000;	//
	D_7460 : real := +0.0;	//
	D_7461 : int  := 00000;	//
	D_7462 : int  := 00000;	//
	D_7463 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_7464 : int  := 00000;	//
	D_7465 : int  := +00000;	//
	D_7466 : word  := B#(000,000);	//
	D_7467 : int  := +00000;	//
	D_7468 : real := 480.000000000000;	// Limit (1)
	D_7469 : real := +0.0;	//
	D_7470 : int  := +00000;	//
	D_7471 : word := 2#0000000000000000;	//
	D_7472 : int := +00000;	//
	D_7473 : real := 470.000000000000;	// Limit (2)
	D_7474 : real := +0.0;	//
	D_7475 : int  := +00000;	//
	D_7476 : word := 2#0000000000000000;	//
	D_7477 : int := +00000;	//
	D_7478 : real := 460.000000000000;	// Limit (3)
	D_7479 : real := +0.0;	//
	D_7480 : int  := +00000;	//
	D_7481 : word := 2#0000000000000000;	//
	D_7482 : int := +00000;	//
	D_7483 : real := 420.000000000000;	// Limit (4)
	D_7484 : real := +0.0;	//
	D_7485 : int  := +00000;	//
	D_7486 : word := 2#0000000000000000;	//
	D_7487 : int := +00000;	//
	D_7488 : real := 400.000000000000;	// Limit (5)
	D_7489 : real := +0.0;	//
	D_7490 : int  := +00000;	//
	D_7491 : word := 2#0000000000000000;	//
	D_7492 : int := +00000;	//
	D_7493 : word := B#(  2,  1);	//  050104 ( 02629 )
	D_7494 : word := 2#0000000000000100;	// GEN 1 CORRIENTE L1
	D_7495 : real := +0.0;
	D_7496 : word := 2#0000000000000000;
	D_7497 : int  := +00000;
	D_7498 : int  := +00000;
	D_7499 : int  := +00000;
	D_7500 : word := B#(  0, 0);
	D_7501 : word := B#(000,000);
	D_7502 : word := 2#0000000000000000;
	D_7503 : int  := +00000;
	D_7504 : int  := +00000;
	D_7505 : word := B#(  1,  1);	// State (1)
	D_7506 : word := B#(  0,  0);	//
	D_7507 : word := B#(  0,  0);	//
	D_7508 : int  := +00000;	//
	D_7509 : word := 2#0000000000000000;	//
	D_7510 : word := B#(  0,  0);	//
	D_7511 : word := B#(  1,  1);	// State (16)
	D_7512 : word := B#(  0,  1);	//
	D_7513 : word := B#(  15,  12);	//
	D_7514 : int  := +00000;	//
	D_7515 : word := 2#0000000000000000;	//
	D_7516 : word := B#(  0,  0);	//
	D_7517 : real := 0.000000000000;	//
	D_7518 : real := 500.000000000000;	//
	D_7519 : real := 5.000000000000;	//
	D_7520 : real := 5.000000000000;	//
	D_7521 : real := +0.0;	//
	D_7522 : int  := 00000;	//
	D_7523 : int  := 00000;	//
	D_7524 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_7525 : int  := 00000;	//
	D_7526 : int  := +00000;	//
	D_7527 : word  := B#(000,000);	//
	D_7528 : int  := +00000;	//
	D_7529 : word := B#(  2,  1);	//  050105 ( 02630 )
	D_7530 : word := 2#0000000000000100;	// GEN 1 CORRIENTE L2
	D_7531 : real := +0.0;
	D_7532 : word := 2#0000000000000000;
	D_7533 : int  := +00000;
	D_7534 : int  := +00000;
	D_7535 : int  := +00000;
	D_7536 : word := B#(  0, 0);
	D_7537 : word := B#(000,000);
	D_7538 : word := 2#0000000000000000;
	D_7539 : int  := +00000;
	D_7540 : int  := +00000;
	D_7541 : word := B#(  1,  1);	// State (1)
	D_7542 : word := B#(  0,  0);	//
	D_7543 : word := B#(  0,  0);	//
	D_7544 : int  := +00000;	//
	D_7545 : word := 2#0000000000000000;	//
	D_7546 : word := B#(  0,  0);	//
	D_7547 : word := B#(  1,  1);	// State (16)
	D_7548 : word := B#(  0,  1);	//
	D_7549 : word := B#(  15,  12);	//
	D_7550 : int  := +00000;	//
	D_7551 : word := 2#0000000000000000;	//
	D_7552 : word := B#(  0,  0);	//
	D_7553 : real := 0.000000000000;	//
	D_7554 : real := 500.000000000000;	//
	D_7555 : real := 5.000000000000;	//
	D_7556 : real := 5.000000000000;	//
	D_7557 : real := +0.0;	//
	D_7558 : int  := 00000;	//
	D_7559 : int  := 00000;	//
	D_7560 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_7561 : int  := 00000;	//
	D_7562 : int  := +00000;	//
	D_7563 : word  := B#(000,000);	//
	D_7564 : int  := +00000;	//
	D_7565 : word := B#(  2,  1);	//  050106 ( 02631 )
	D_7566 : word := 2#0000000000000100;	// GEN 1 CORRIENTE L3
	D_7567 : real := +0.0;
	D_7568 : word := 2#0000000000000000;
	D_7569 : int  := +00000;
	D_7570 : int  := +00000;
	D_7571 : int  := +00000;
	D_7572 : word := B#(  0, 0);
	D_7573 : word := B#(000,000);
	D_7574 : word := 2#0000000000000000;
	D_7575 : int  := +00000;
	D_7576 : int  := +00000;
	D_7577 : word := B#(  1,  1);	// State (1)
	D_7578 : word := B#(  0,  0);	//
	D_7579 : word := B#(  0,  0);	//
	D_7580 : int  := +00000;	//
	D_7581 : word := 2#0000000000000000;	//
	D_7582 : word := B#(  0,  0);	//
	D_7583 : word := B#(  1,  1);	// State (16)
	D_7584 : word := B#(  0,  1);	//
	D_7585 : word := B#(  15,  12);	//
	D_7586 : int  := +00000;	//
	D_7587 : word := 2#0000000000000000;	//
	D_7588 : word := B#(  0,  0);	//
	D_7589 : real := 0.000000000000;	//
	D_7590 : real := 500.000000000000;	//
	D_7591 : real := 5.000000000000;	//
	D_7592 : real := 5.000000000000;	//
	D_7593 : real := +0.0;	//
	D_7594 : int  := 00000;	//
	D_7595 : int  := 00000;	//
	D_7596 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_7597 : int  := 00000;	//
	D_7598 : int  := +00000;	//
	D_7599 : word  := B#(000,000);	//
	D_7600 : int  := +00000;	//
	D_7601 : word := B#(  2,  5);	//  050107 ( 02632 )
	D_7602 : word := 2#0000000000000100;	// GEN 1 POTENCIA KW
	D_7603 : real := +0.0;
	D_7604 : word := 2#0000000000000000;
	D_7605 : int  := +00000;
	D_7606 : int  := +00000;
	D_7607 : int  := +00000;
	D_7608 : word := B#(  0, 0);
	D_7609 : word := B#(000,000);
	D_7610 : word := 2#0000000000000000;
	D_7611 : int  := +00000;
	D_7612 : int  := +00000;
	D_7613 : word := B#(  1,  1);	// State (1)
	D_7614 : word := B#(  0,  1);	//
	D_7615 : word := B#(  14,  0);	//
	D_7616 : int  := +00000;	//
	D_7617 : word := 2#0000000000000000;	//
	D_7618 : word := B#(  0,  0);	//
	D_7619 : word := B#(  1,  1);	// State (2)
	D_7620 : word := B#(  0,  1);	//
	D_7621 : word := B#(  13,  0);	//
	D_7622 : int  := +00000;	//
	D_7623 : word := 2#0000000000000000;	//
	D_7624 : word := B#(  0,  0);	//
	D_7625 : word := B#(  1,  1);	// State (3)
	D_7626 : word := B#(  0,  1);	//
	D_7627 : word := B#(  12,  0);	//
	D_7628 : int  := +00000;	//
	D_7629 : word := 2#0000000000000000;	//
	D_7630 : word := B#(  0,  0);	//
	D_7631 : word := B#(  1,  1);	// State (4)
	D_7632 : word := B#(  0,  0);	//
	D_7633 : word := B#(  0,  0);	//
	D_7634 : int  := +00000;	//
	D_7635 : word := 2#0000000000000000;	//
	D_7636 : word := B#(  0,  0);	//
	D_7637 : word := B#(  1,  1);	// State (5)
	D_7638 : word := B#(  0,  1);	//
	D_7639 : word := B#(  8,  1);	//
	D_7640 : int  := +00000;	//
	D_7641 : word := 2#0000000000000000;	//
	D_7642 : word := B#(  0,  0);	//
	D_7643 : word := B#(  1,  1);	// State (16)
	D_7644 : word := B#(  0,  1);	//
	D_7645 : word := B#(  15,  12);	//
	D_7646 : int  := +00000;	//
	D_7647 : word := 2#0000000000000000;	//
	D_7648 : word := B#(  0,  0);	//
	D_7649 : real := -20.000000000000;	//
	D_7650 : real := 200.000000000000;	//
	D_7651 : real := 2.200000000000;	//
	D_7652 : real := 2.200000000000;	//
	D_7653 : real := +0.0;	//
	D_7654 : int  := 00000;	//
	D_7655 : int  := 00000;	//
	D_7656 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_7657 : int  := 00000;	//
	D_7658 : int  := +00000;	//
	D_7659 : word  := B#(000,000);	//
	D_7660 : int  := +00000;	//
	D_7661 : real := 190.000000000000;	// Limit (1)
	D_7662 : real := +0.0;	//
	D_7663 : int  := +00000;	//
	D_7664 : word := 2#0000000000000000;	//
	D_7665 : int := +00000;	//
	D_7666 : real := 180.000000000000;	// Limit (2)
	D_7667 : real := +0.0;	//
	D_7668 : int  := +00000;	//
	D_7669 : word := 2#0000000000000000;	//
	D_7670 : int := +00000;	//
	D_7671 : real := 150.000000000000;	// Limit (3)
	D_7672 : real := +0.0;	//
	D_7673 : int  := +00000;	//
	D_7674 : word := 2#0000000000000000;	//
	D_7675 : int := +00000;	//
	D_7676 : real := -18.000000000000;	// Limit (4)
	D_7677 : real := +0.0;	//
	D_7678 : int  := +00000;	//
	D_7679 : word := 2#0000000000000000;	//
	D_7680 : int := +00000;	//
	D_7681 : word := B#(  2,  1);	//  050108 ( 02633 )
	D_7682 : word := 2#0000000000000100;	// GEN 1 FACTOR DE POTENCIA
	D_7683 : real := +0.0;
	D_7684 : word := 2#0000000000000000;
	D_7685 : int  := +00000;
	D_7686 : int  := +00000;
	D_7687 : int  := +00000;
	D_7688 : word := B#(  0, 0);
	D_7689 : word := B#(000,000);
	D_7690 : word := 2#0000000000000000;
	D_7691 : int  := +00000;
	D_7692 : int  := +00000;
	D_7693 : word := B#(  1,  1);	// State (1)
	D_7694 : word := B#(  0,  0);	//
	D_7695 : word := B#(  0,  0);	//
	D_7696 : int  := +00000;	//
	D_7697 : word := 2#0000000000000000;	//
	D_7698 : word := B#(  0,  0);	//
	D_7699 : word := B#(  1,  1);	// State (16)
	D_7700 : word := B#(  0,  1);	//
	D_7701 : word := B#(  15,  12);	//
	D_7702 : int  := +00000;	//
	D_7703 : word := 2#0000000000000000;	//
	D_7704 : word := B#(  0,  0);	//
	D_7705 : real := -1.000000000000;	//
	D_7706 : real := 1.000000000000;	//
	D_7707 : real := 0.020000000000;	//
	D_7708 : real := 0.020000000000;	//
	D_7709 : real := +0.0;	//
	D_7710 : int  := 00000;	//
	D_7711 : int  := 00000;	//
	D_7712 : word  := B#(002,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_7713 : int  := 00000;	//
	D_7714 : int  := +00000;	//
	D_7715 : word  := B#(000,000);	//
	D_7716 : int  := +00000;	//
	D_7717 : word := B#(  2,  1);	//  050109 ( 02634 )
	D_7718 : word := 2#0000000000000100;	// GEN 1 POTENCIA REACTIVE KVAR
	D_7719 : real := +0.0;
	D_7720 : word := 2#0000000000000000;
	D_7721 : int  := +00000;
	D_7722 : int  := +00000;
	D_7723 : int  := +00000;
	D_7724 : word := B#(  0, 0);
	D_7725 : word := B#(000,000);
	D_7726 : word := 2#0000000000000000;
	D_7727 : int  := +00000;
	D_7728 : int  := +00000;
	D_7729 : word := B#(  1,  1);	// State (1)
	D_7730 : word := B#(  0,  0);	//
	D_7731 : word := B#(  0,  0);	//
	D_7732 : int  := +00000;	//
	D_7733 : word := 2#0000000000000000;	//
	D_7734 : word := B#(  0,  0);	//
	D_7735 : word := B#(  1,  1);	// State (16)
	D_7736 : word := B#(  0,  1);	//
	D_7737 : word := B#(  15,  12);	//
	D_7738 : int  := +00000;	//
	D_7739 : word := 2#0000000000000000;	//
	D_7740 : word := B#(  0,  0);	//
	D_7741 : real := 0.000000000000;	//
	D_7742 : real := 150.000000000000;	//
	D_7743 : real := 1.500000000000;	//
	D_7744 : real := 1.500000000000;	//
	D_7745 : real := +0.0;	//
	D_7746 : int  := 00000;	//
	D_7747 : int  := 00000;	//
	D_7748 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_7749 : int  := 00000;	//
	D_7750 : int  := +00000;	//
	D_7751 : word  := B#(000,000);	//
	D_7752 : int  := +00000;	//
	D_7753 : word := B#(  2,  5);	//  050115 ( 02635 )
	D_7754 : word := 2#0000000000000100;	// GEN 1 FRECUENCIA
	D_7755 : real := +0.0;
	D_7756 : word := 2#0000000000000000;
	D_7757 : int  := +00024;
	D_7758 : int  := +00000;
	D_7759 : int  := +00000;
	D_7760 : word := B#(  0, 0);
	D_7761 : word := B#(000,000);
	D_7762 : word := 2#0000000000000000;
	D_7763 : int  := +00000;
	D_7764 : int  := +00000;
	D_7765 : word := B#(  5,  5);	// State (1)
	D_7766 : word := B#(  0,  1);	//
	D_7767 : word := B#(  13,  0);	//
	D_7768 : int  := +00000;	//
	D_7769 : word := 2#0000000000000000;	//
	D_7770 : word := B#(  0,  0);	//
	D_7771 : word := B#(  5,  5);	// State (2)
	D_7772 : word := B#(  0,  0);	//
	D_7773 : word := B#(  0,  0);	//
	D_7774 : int  := +00000;	//
	D_7775 : word := 2#0000000000000000;	//
	D_7776 : word := B#(  0,  0);	//
	D_7777 : word := B#(  10,  10);	// State (3)
	D_7778 : word := B#(  0,  1);	//
	D_7779 : word := B#(  6,  1);	//
	D_7780 : int  := +00000;	//
	D_7781 : word := 2#0000000000000000;	//
	D_7782 : word := B#(  0,  0);	//
	D_7783 : word := B#(  10,  10);	// State (4)
	D_7784 : word := B#(  0,  1);	//
	D_7785 : word := B#(  7,  1);	//
	D_7786 : int  := +00202;	//
	D_7787 : word := 2#0000000000000000;	//
	D_7788 : word := B#(  0,  0);	//
	D_7789 : word := B#(  10,  10);	// State (5)
	D_7790 : word := B#(  0,  1);	//
	D_7791 : word := B#(  8,  1);	//
	D_7792 : int  := +00202;	//
	D_7793 : word := 2#0000000000000000;	//
	D_7794 : word := B#(  0,  0);	//
	D_7795 : word := B#(  5,  5);	// State (16)
	D_7796 : word := B#(  0,  1);	//
	D_7797 : word := B#(  15,  12);	//
	D_7798 : int  := +00202;	//
	D_7799 : word := 2#0000000000000000;	//
	D_7800 : word := B#(  0,  0);	//
	D_7801 : real := 0.000000000000;	//
	D_7802 : real := 65.000000000000;	//
	D_7803 : real := 0.325000000000;	//
	D_7804 : real := 0.650000000000;	//
	D_7805 : real := +0.0;	//
	D_7806 : int  := 00000;	//
	D_7807 : int  := 00000;	//
	D_7808 : word  := B#(001,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_7809 : int  := 00000;	//
	D_7810 : int  := +00000;	//
	D_7811 : word  := B#(000,000);	//
	D_7812 : int  := +00000;	//
	D_7813 : real := 62.500000000000;	// Limit (1)
	D_7814 : real := +0.0;	//
	D_7815 : int  := +00000;	//
	D_7816 : word := 2#0000000000000000;	//
	D_7817 : int := +00000;	//
	D_7818 : real := 57.500000000000;	// Limit (2)
	D_7819 : real := +0.0;	//
	D_7820 : int  := +00000;	//
	D_7821 : word := 2#0000000000000000;	//
	D_7822 : int := +00000;	//
	D_7823 : real := 56.000000000000;	// Limit (3)
	D_7824 : real := +0.0;	//
	D_7825 : int  := +00000;	//
	D_7826 : word := 2#0000000000000000;	//
	D_7827 : int := +00000;	//
	D_7828 : real := 55.000000000000;	// Limit (4)
	D_7829 : real := +0.0;	//
	D_7830 : int  := +00000;	//
	D_7831 : word := 2#0000000000000000;	//
	D_7832 : int := +00000;	//
	D_7833 : word := B#(  2,  6);	//  050201 ( 02636 )
	D_7834 : word := 2#0000000000000100;	// GEN 2 VOLTAJE L1-L2
	D_7835 : real := +0.0;
	D_7836 : word := 2#0000000000000000;
	D_7837 : int  := +00048;
	D_7838 : int  := +00000;
	D_7839 : int  := +00000;
	D_7840 : word := B#(  0, 0);
	D_7841 : word := B#(000,000);
	D_7842 : word := 2#0000000000000000;
	D_7843 : int  := +00000;
	D_7844 : int  := +00000;
	D_7845 : word := B#(  5,  5);	// State (1)
	D_7846 : word := B#(  0,  1);	//
	D_7847 : word := B#(  14,  0);	//
	D_7848 : int  := +00000;	//
	D_7849 : word := 2#0000000000000000;	//
	D_7850 : word := B#(  0,  0);	//
	D_7851 : word := B#(  5,  5);	// State (2)
	D_7852 : word := B#(  0,  1);	//
	D_7853 : word := B#(  13,  0);	//
	D_7854 : int  := +00000;	//
	D_7855 : word := 2#0000000000000000;	//
	D_7856 : word := B#(  0,  0);	//
	D_7857 : word := B#(  5,  5);	// State (3)
	D_7858 : word := B#(  0,  1);	//
	D_7859 : word := B#(  12,  0);	//
	D_7860 : int  := +00000;	//
	D_7861 : word := 2#0000000000000000;	//
	D_7862 : word := B#(  0,  0);	//
	D_7863 : word := B#(  5,  5);	// State (4)
	D_7864 : word := B#(  0,  0);	//
	D_7865 : word := B#(  0,  0);	//
	D_7866 : int  := +00000;	//
	D_7867 : word := 2#0000000000000000;	//
	D_7868 : word := B#(  0,  0);	//
	D_7869 : word := B#(  10,  10);	// State (5)
	D_7870 : word := B#(  0,  1);	//
	D_7871 : word := B#(  3,  5);	//
	D_7872 : int  := +00203;	//
	D_7873 : word := 2#0000000000000000;	//
	D_7874 : word := B#(  0,  0);	//
	D_7875 : word := B#(  10,  10);	// State (6)
	D_7876 : word := B#(  0,  1);	//
	D_7877 : word := B#(  8,  1);	//
	D_7878 : int  := +00203;	//
	D_7879 : word := 2#0000000000000000;	//
	D_7880 : word := B#(  0,  0);	//
	D_7881 : word := B#(  5,  5);	// State (16)
	D_7882 : word := B#(  0,  1);	//
	D_7883 : word := B#(  15,  12);	//
	D_7884 : int  := +00203;	//
	D_7885 : word := 2#0000000000000000;	//
	D_7886 : word := B#(  0,  0);	//
	D_7887 : real := 0.000000000000;	//
	D_7888 : real := 600.000000000000;	//
	D_7889 : real := 6.000000000000;	//
	D_7890 : real := 6.000000000000;	//
	D_7891 : real := +0.0;	//
	D_7892 : int  := 00000;	//
	D_7893 : int  := 00000;	//
	D_7894 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_7895 : int  := 00000;	//
	D_7896 : int  := +00000;	//
	D_7897 : word  := B#(000,000);	//
	D_7898 : int  := +00000;	//
	D_7899 : real := 480.000000000000;	// Limit (1)
	D_7900 : real := +0.0;	//
	D_7901 : int  := +00000;	//
	D_7902 : word := 2#0000000000000000;	//
	D_7903 : int := +00000;	//
	D_7904 : real := 470.000000000000;	// Limit (2)
	D_7905 : real := +0.0;	//
	D_7906 : int  := +00000;	//
	D_7907 : word := 2#0000000000000000;	//
	D_7908 : int := +00000;	//
	D_7909 : real := 460.000000000000;	// Limit (3)
	D_7910 : real := +0.0;	//
	D_7911 : int  := +00000;	//
	D_7912 : word := 2#0000000000000000;	//
	D_7913 : int := +00000;	//
	D_7914 : real := 420.000000000000;	// Limit (4)
	D_7915 : real := +0.0;	//
	D_7916 : int  := +00000;	//
	D_7917 : word := 2#0000000000000000;	//
	D_7918 : int := +00000;	//
	D_7919 : real := 400.000000000000;	// Limit (5)
	D_7920 : real := +0.0;	//
	D_7921 : int  := +00000;	//
	D_7922 : word := 2#0000000000000000;	//
	D_7923 : int := +00000;	//
	D_7924 : word := B#(  2,  6);	//  050202 ( 02637 )
	D_7925 : word := 2#0000000000000100;	// GEN 2 VOLTAJE L1-L3
	D_7926 : real := +0.0;
	D_7927 : word := 2#0000000000000000;
	D_7928 : int  := +00048;
	D_7929 : int  := +00000;
	D_7930 : int  := +00000;
	D_7931 : word := B#(  0, 0);
	D_7932 : word := B#(000,000);
	D_7933 : word := 2#0000000000000000;
	D_7934 : int  := +00000;
	D_7935 : int  := +00000;
	D_7936 : word := B#(  5,  5);	// State (1)
	D_7937 : word := B#(  0,  1);	//
	D_7938 : word := B#(  14,  0);	//
	D_7939 : int  := +00000;	//
	D_7940 : word := 2#0000000000000000;	//
	D_7941 : word := B#(  0,  0);	//
	D_7942 : word := B#(  5,  5);	// State (2)
	D_7943 : word := B#(  0,  1);	//
	D_7944 : word := B#(  13,  0);	//
	D_7945 : int  := +00000;	//
	D_7946 : word := 2#0000000000000000;	//
	D_7947 : word := B#(  0,  0);	//
	D_7948 : word := B#(  5,  5);	// State (3)
	D_7949 : word := B#(  0,  1);	//
	D_7950 : word := B#(  12,  0);	//
	D_7951 : int  := +00000;	//
	D_7952 : word := 2#0000000000000000;	//
	D_7953 : word := B#(  0,  0);	//
	D_7954 : word := B#(  5,  5);	// State (4)
	D_7955 : word := B#(  0,  0);	//
	D_7956 : word := B#(  0,  0);	//
	D_7957 : int  := +00000;	//
	D_7958 : word := 2#0000000000000000;	//
	D_7959 : word := B#(  0,  0);	//
	D_7960 : word := B#(  10,  10);	// State (5)
	D_7961 : word := B#(  0,  1);	//
	D_7962 : word := B#(  3,  5);	//
	D_7963 : int  := +00203;	//
	D_7964 : word := 2#0000000000000000;	//
	D_7965 : word := B#(  0,  0);	//
	D_7966 : word := B#(  10,  10);	// State (6)
	D_7967 : word := B#(  0,  1);	//
	D_7968 : word := B#(  8,  1);	//
	D_7969 : int  := +00203;	//
	D_7970 : word := 2#0000000000000000;	//
	D_7971 : word := B#(  0,  0);	//
	D_7972 : word := B#(  5,  5);	// State (16)
	D_7973 : word := B#(  0,  1);	//
	D_7974 : word := B#(  15,  12);	//
	D_7975 : int  := +00203;	//
	D_7976 : word := 2#0000000000000000;	//
	D_7977 : word := B#(  0,  0);	//
	D_7978 : real := 0.000000000000;	//
	D_7979 : real := 600.000000000000;	//
	D_7980 : real := 6.000000000000;	//
	D_7981 : real := 6.000000000000;	//
	D_7982 : real := +0.0;	//
	D_7983 : int  := 00000;	//
	D_7984 : int  := 00000;	//
	D_7985 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_7986 : int  := 00000;	//
	D_7987 : int  := +00000;	//
	D_7988 : word  := B#(000,000);	//
	D_7989 : int  := +00000;	//
	D_7990 : real := 480.000000000000;	// Limit (1)
	D_7991 : real := +0.0;	//
	D_7992 : int  := +00000;	//
	D_7993 : word := 2#0000000000000000;	//
	D_7994 : int := +00000;	//
	D_7995 : real := 470.000000000000;	// Limit (2)
	D_7996 : real := +0.0;	//
	D_7997 : int  := +00000;	//
	D_7998 : word := 2#0000000000000000;	//
	D_7999 : int := +00000;	//
	D_8000 : real := 460.000000000000;	// Limit (3)
	D_8001 : real := +0.0;	//
	D_8002 : int  := +00000;	//
	D_8003 : word := 2#0000000000000000;	//
	D_8004 : int := +00000;	//
	D_8005 : real := 420.000000000000;	// Limit (4)
	D_8006 : real := +0.0;	//
	D_8007 : int  := +00000;	//
	D_8008 : word := 2#0000000000000000;	//
	D_8009 : int := +00000;	//
	D_8010 : real := 400.000000000000;	// Limit (5)
	D_8011 : real := +0.0;	//
	D_8012 : int  := +00000;	//
	D_8013 : word := 2#0000000000000000;	//
	D_8014 : int := +00000;	//
	D_8015 : word := B#(  2,  6);	//  050203 ( 02638 )
	D_8016 : word := 2#0000000000000100;	// GEN 2 VOLTAJE L2-L3
	D_8017 : real := +0.0;
	D_8018 : word := 2#0000000000000000;
	D_8019 : int  := +00048;
	D_8020 : int  := +00000;
	D_8021 : int  := +00000;
	D_8022 : word := B#(  0, 0);
	D_8023 : word := B#(000,000);
	D_8024 : word := 2#0000000000000000;
	D_8025 : int  := +00000;
	D_8026 : int  := +00000;
	D_8027 : word := B#(  5,  5);	// State (1)
	D_8028 : word := B#(  0,  1);	//
	D_8029 : word := B#(  14,  0);	//
	D_8030 : int  := +00000;	//
	D_8031 : word := 2#0000000000000000;	//
	D_8032 : word := B#(  0,  0);	//
	D_8033 : word := B#(  5,  5);	// State (2)
	D_8034 : word := B#(  0,  1);	//
	D_8035 : word := B#(  13,  0);	//
	D_8036 : int  := +00000;	//
	D_8037 : word := 2#0000000000000000;	//
	D_8038 : word := B#(  0,  0);	//
	D_8039 : word := B#(  5,  5);	// State (3)
	D_8040 : word := B#(  0,  1);	//
	D_8041 : word := B#(  12,  0);	//
	D_8042 : int  := +00000;	//
	D_8043 : word := 2#0000000000000000;	//
	D_8044 : word := B#(  0,  0);	//
	D_8045 : word := B#(  5,  5);	// State (4)
	D_8046 : word := B#(  0,  0);	//
	D_8047 : word := B#(  0,  0);	//
	D_8048 : int  := +00000;	//
	D_8049 : word := 2#0000000000000000;	//
	D_8050 : word := B#(  0,  0);	//
	D_8051 : word := B#(  10,  10);	// State (5)
	D_8052 : word := B#(  0,  1);	//
	D_8053 : word := B#(  3,  5);	//
	D_8054 : int  := +00203;	//
	D_8055 : word := 2#0000000000000000;	//
	D_8056 : word := B#(  0,  0);	//
	D_8057 : word := B#(  10,  10);	// State (6)
	D_8058 : word := B#(  0,  1);	//
	D_8059 : word := B#(  8,  1);	//
	D_8060 : int  := +00203;	//
	D_8061 : word := 2#0000000000000000;	//
	D_8062 : word := B#(  0,  0);	//
	D_8063 : word := B#(  5,  5);	// State (16)
	D_8064 : word := B#(  0,  1);	//
	D_8065 : word := B#(  15,  12);	//
	D_8066 : int  := +00203;	//
	D_8067 : word := 2#0000000000000000;	//
	D_8068 : word := B#(  0,  0);	//
	D_8069 : real := 0.000000000000;	//
	D_8070 : real := 600.000000000000;	//
	D_8071 : real := 6.000000000000;	//
	D_8072 : real := 6.000000000000;	//
	D_8073 : real := +0.0;	//
	D_8074 : int  := 00000;	//
	D_8075 : int  := 00000;	//
	D_8076 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_8077 : int  := 00000;	//
	D_8078 : int  := +00000;	//
	D_8079 : word  := B#(000,000);	//
	D_8080 : int  := +00000;	//
	D_8081 : real := 480.000000000000;	// Limit (1)
	D_8082 : real := +0.0;	//
	D_8083 : int  := +00000;	//
	D_8084 : word := 2#0000000000000000;	//
	D_8085 : int := +00000;	//
	D_8086 : real := 470.000000000000;	// Limit (2)
	D_8087 : real := +0.0;	//
	D_8088 : int  := +00000;	//
	D_8089 : word := 2#0000000000000000;	//
	D_8090 : int := +00000;	//
	D_8091 : real := 460.000000000000;	// Limit (3)
	D_8092 : real := +0.0;	//
	D_8093 : int  := +00000;	//
	D_8094 : word := 2#0000000000000000;	//
	D_8095 : int := +00000;	//
	D_8096 : real := 420.000000000000;	// Limit (4)
	D_8097 : real := +0.0;	//
	D_8098 : int  := +00000;	//
	D_8099 : word := 2#0000000000000000;	//
	D_8100 : int := +00000;	//
	D_8101 : real := 400.000000000000;	// Limit (5)
	D_8102 : real := +0.0;	//
	D_8103 : int  := +00000;	//
	D_8104 : word := 2#0000000000000000;	//
	D_8105 : int := +00000;	//
	D_8106 : word := B#(  2,  1);	//  050204 ( 02639 )
	D_8107 : word := 2#0000000000000100;	// GEN 2 CORRIENTE L1
	D_8108 : real := +0.0;
	D_8109 : word := 2#0000000000000000;
	D_8110 : int  := +00000;
	D_8111 : int  := +00000;
	D_8112 : int  := +00000;
	D_8113 : word := B#(  0, 0);
	D_8114 : word := B#(000,000);
	D_8115 : word := 2#0000000000000000;
	D_8116 : int  := +00000;
	D_8117 : int  := +00000;
	D_8118 : word := B#(  1,  1);	// State (1)
	D_8119 : word := B#(  0,  0);	//
	D_8120 : word := B#(  0,  0);	//
	D_8121 : int  := +00000;	//
	D_8122 : word := 2#0000000000000000;	//
	D_8123 : word := B#(  0,  0);	//
	D_8124 : word := B#(  1,  1);	// State (16)
	D_8125 : word := B#(  0,  1);	//
	D_8126 : word := B#(  15,  12);	//
	D_8127 : int  := +00000;	//
	D_8128 : word := 2#0000000000000000;	//
	D_8129 : word := B#(  0,  0);	//
	D_8130 : real := 0.000000000000;	//
	D_8131 : real := 500.000000000000;	//
	D_8132 : real := 5.000000000000;	//
	D_8133 : real := 5.000000000000;	//
	D_8134 : real := +0.0;	//
	D_8135 : int  := 00000;	//
	D_8136 : int  := 00000;	//
	D_8137 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_8138 : int  := 00000;	//
	D_8139 : int  := +00000;	//
	D_8140 : word  := B#(000,000);	//
	D_8141 : int  := +00000;	//
	D_8142 : word := B#(  2,  1);	//  050205 ( 02640 )
	D_8143 : word := 2#0000000000000100;	// GEN 2 CORRIENTE L2
	D_8144 : real := +0.0;
	D_8145 : word := 2#0000000000000000;
	D_8146 : int  := +00000;
	D_8147 : int  := +00000;
	D_8148 : int  := +00000;
	D_8149 : word := B#(  0, 0);
	D_8150 : word := B#(000,000);
	D_8151 : word := 2#0000000000000000;
	D_8152 : int  := +00000;
	D_8153 : int  := +00000;
	D_8154 : word := B#(  1,  1);	// State (1)
	D_8155 : word := B#(  0,  0);	//
	D_8156 : word := B#(  0,  0);	//
	D_8157 : int  := +00000;	//
	D_8158 : word := 2#0000000000000000;	//
	D_8159 : word := B#(  0,  0);	//
	D_8160 : word := B#(  1,  1);	// State (16)
	D_8161 : word := B#(  0,  1);	//
	D_8162 : word := B#(  15,  12);	//
	D_8163 : int  := +00000;	//
	D_8164 : word := 2#0000000000000000;	//
	D_8165 : word := B#(  0,  0);	//
	D_8166 : real := 0.000000000000;	//
	D_8167 : real := 500.000000000000;	//
	D_8168 : real := 5.000000000000;	//
	D_8169 : real := 5.000000000000;	//
	D_8170 : real := +0.0;	//
	D_8171 : int  := 00000;	//
	D_8172 : int  := 00000;	//
	D_8173 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_8174 : int  := 00000;	//
	D_8175 : int  := +00000;	//
	D_8176 : word  := B#(000,000);	//
	D_8177 : int  := +00000;	//
	D_8178 : word := B#(  2,  1);	//  050206 ( 02641 )
	D_8179 : word := 2#0000000000000100;	// GEN 2 CORRIENTE L3
	D_8180 : real := +0.0;
	D_8181 : word := 2#0000000000000000;
	D_8182 : int  := +00000;
	D_8183 : int  := +00000;
	D_8184 : int  := +00000;
	D_8185 : word := B#(  0, 0);
	D_8186 : word := B#(000,000);
	D_8187 : word := 2#0000000000000000;
	D_8188 : int  := +00000;
	D_8189 : int  := +00000;
	D_8190 : word := B#(  1,  1);	// State (1)
	D_8191 : word := B#(  0,  0);	//
	D_8192 : word := B#(  0,  0);	//
	D_8193 : int  := +00000;	//
	D_8194 : word := 2#0000000000000000;	//
	D_8195 : word := B#(  0,  0);	//
	D_8196 : word := B#(  1,  1);	// State (16)
	D_8197 : word := B#(  0,  1);	//
	D_8198 : word := B#(  15,  12);	//
	D_8199 : int  := +00000;	//
	D_8200 : word := 2#0000000000000000;	//
	D_8201 : word := B#(  0,  0);	//
	D_8202 : real := 0.000000000000;	//
	D_8203 : real := 500.000000000000;	//
	D_8204 : real := 5.000000000000;	//
	D_8205 : real := 5.000000000000;	//
	D_8206 : real := +0.0;	//
	D_8207 : int  := 00000;	//
	D_8208 : int  := 00000;	//
	D_8209 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_8210 : int  := 00000;	//
	D_8211 : int  := +00000;	//
	D_8212 : word  := B#(000,000);	//
	D_8213 : int  := +00000;	//
	D_8214 : word := B#(  2,  5);	//  050207 ( 02642 )
	D_8215 : word := 2#0000000000000100;	// GEN 2 POTENCIA KW
	D_8216 : real := +0.0;
	D_8217 : word := 2#0000000000000000;
	D_8218 : int  := +00000;
	D_8219 : int  := +00000;
	D_8220 : int  := +00000;
	D_8221 : word := B#(  0, 0);
	D_8222 : word := B#(000,000);
	D_8223 : word := 2#0000000000000000;
	D_8224 : int  := +00000;
	D_8225 : int  := +00000;
	D_8226 : word := B#(  1,  1);	// State (1)
	D_8227 : word := B#(  0,  1);	//
	D_8228 : word := B#(  14,  0);	//
	D_8229 : int  := +00000;	//
	D_8230 : word := 2#0000000000000000;	//
	D_8231 : word := B#(  0,  0);	//
	D_8232 : word := B#(  1,  1);	// State (2)
	D_8233 : word := B#(  0,  1);	//
	D_8234 : word := B#(  13,  0);	//
	D_8235 : int  := +00000;	//
	D_8236 : word := 2#0000000000000000;	//
	D_8237 : word := B#(  0,  0);	//
	D_8238 : word := B#(  1,  1);	// State (3)
	D_8239 : word := B#(  0,  1);	//
	D_8240 : word := B#(  12,  0);	//
	D_8241 : int  := +00000;	//
	D_8242 : word := 2#0000000000000000;	//
	D_8243 : word := B#(  0,  0);	//
	D_8244 : word := B#(  1,  1);	// State (4)
	D_8245 : word := B#(  0,  0);	//
	D_8246 : word := B#(  0,  0);	//
	D_8247 : int  := +00000;	//
	D_8248 : word := 2#0000000000000000;	//
	D_8249 : word := B#(  0,  0);	//
	D_8250 : word := B#(  1,  1);	// State (5)
	D_8251 : word := B#(  0,  1);	//
	D_8252 : word := B#(  8,  1);	//
	D_8253 : int  := +00000;	//
	D_8254 : word := 2#0000000000000000;	//
	D_8255 : word := B#(  0,  0);	//
	D_8256 : word := B#(  1,  1);	// State (16)
	D_8257 : word := B#(  0,  1);	//
	D_8258 : word := B#(  15,  12);	//
	D_8259 : int  := +00000;	//
	D_8260 : word := 2#0000000000000000;	//
	D_8261 : word := B#(  0,  0);	//
	D_8262 : real := -20.000000000000;	//
	D_8263 : real := 200.000000000000;	//
	D_8264 : real := 2.200000000000;	//
	D_8265 : real := 2.200000000000;	//
	D_8266 : real := +0.0;	//
	D_8267 : int  := 00000;	//
	D_8268 : int  := 00000;	//
	D_8269 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_8270 : int  := 00000;	//
	D_8271 : int  := +00000;	//
	D_8272 : word  := B#(000,000);	//
	D_8273 : int  := +00000;	//
	D_8274 : real := 190.000000000000;	// Limit (1)
	D_8275 : real := +0.0;	//
	D_8276 : int  := +00000;	//
	D_8277 : word := 2#0000000000000000;	//
	D_8278 : int := +00000;	//
	D_8279 : real := 180.000000000000;	// Limit (2)
	D_8280 : real := +0.0;	//
	D_8281 : int  := +00000;	//
	D_8282 : word := 2#0000000000000000;	//
	D_8283 : int := +00000;	//
	D_8284 : real := 150.000000000000;	// Limit (3)
	D_8285 : real := +0.0;	//
	D_8286 : int  := +00000;	//
	D_8287 : word := 2#0000000000000000;	//
	D_8288 : int := +00000;	//
	D_8289 : real := -18.000000000000;	// Limit (4)
	D_8290 : real := +0.0;	//
	D_8291 : int  := +00000;	//
	D_8292 : word := 2#0000000000000000;	//
	D_8293 : int := +00000;	//
	D_8294 : word := B#(  2,  1);	//  050208 ( 02643 )
	D_8295 : word := 2#0000000000000100;	// GEN 2 FACTOR DE POTENCIA
	D_8296 : real := +0.0;
	D_8297 : word := 2#0000000000000000;
	D_8298 : int  := +00000;
	D_8299 : int  := +00000;
	D_8300 : int  := +00000;
	D_8301 : word := B#(  0, 0);
	D_8302 : word := B#(000,000);
	D_8303 : word := 2#0000000000000000;
	D_8304 : int  := +00000;
	D_8305 : int  := +00000;
	D_8306 : word := B#(  1,  1);	// State (1)
	D_8307 : word := B#(  0,  0);	//
	D_8308 : word := B#(  0,  0);	//
	D_8309 : int  := +00000;	//
	D_8310 : word := 2#0000000000000000;	//
	D_8311 : word := B#(  0,  0);	//
	D_8312 : word := B#(  1,  1);	// State (16)
	D_8313 : word := B#(  0,  1);	//
	D_8314 : word := B#(  15,  12);	//
	D_8315 : int  := +00000;	//
	D_8316 : word := 2#0000000000000000;	//
	D_8317 : word := B#(  0,  0);	//
	D_8318 : real := -1.000000000000;	//
	D_8319 : real := 1.000000000000;	//
	D_8320 : real := 0.020000000000;	//
	D_8321 : real := 0.020000000000;	//
	D_8322 : real := +0.0;	//
	D_8323 : int  := 00000;	//
	D_8324 : int  := 00000;	//
	D_8325 : word  := B#(002,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_8326 : int  := 00000;	//
	D_8327 : int  := +00000;	//
	D_8328 : word  := B#(000,000);	//
	D_8329 : int  := +00000;	//
	D_8330 : word := B#(  2,  1);	//  050209 ( 02644 )
	D_8331 : word := 2#0000000000000100;	// GEN 2 POTENCIA REACTIVE KVAR
	D_8332 : real := +0.0;
	D_8333 : word := 2#0000000000000000;
	D_8334 : int  := +00000;
	D_8335 : int  := +00000;
	D_8336 : int  := +00000;
	D_8337 : word := B#(  0, 0);
	D_8338 : word := B#(000,000);
	D_8339 : word := 2#0000000000000000;
	D_8340 : int  := +00000;
	D_8341 : int  := +00000;
	D_8342 : word := B#(  1,  1);	// State (1)
	D_8343 : word := B#(  0,  0);	//
	D_8344 : word := B#(  0,  0);	//
	D_8345 : int  := +00000;	//
	D_8346 : word := 2#0000000000000000;	//
	D_8347 : word := B#(  0,  0);	//
	D_8348 : word := B#(  1,  1);	// State (16)
	D_8349 : word := B#(  0,  1);	//
	D_8350 : word := B#(  15,  12);	//
	D_8351 : int  := +00000;	//
	D_8352 : word := 2#0000000000000000;	//
	D_8353 : word := B#(  0,  0);	//
	D_8354 : real := 0.000000000000;	//
	D_8355 : real := 150.000000000000;	//
	D_8356 : real := 1.500000000000;	//
	D_8357 : real := 1.500000000000;	//
	D_8358 : real := +0.0;	//
	D_8359 : int  := 00000;	//
	D_8360 : int  := 00000;	//
	D_8361 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_8362 : int  := 00000;	//
	D_8363 : int  := +00000;	//
	D_8364 : word  := B#(000,000);	//
	D_8365 : int  := +00000;	//
	D_8366 : word := B#(  2,  5);	//  050215 ( 02645 )
	D_8367 : word := 2#0000000000000100;	// GEN 2 FRECUENCIA
	D_8368 : real := +0.0;
	D_8369 : word := 2#0000000000000000;
	D_8370 : int  := +00024;
	D_8371 : int  := +00000;
	D_8372 : int  := +00000;
	D_8373 : word := B#(  0, 0);
	D_8374 : word := B#(000,000);
	D_8375 : word := 2#0000000000000000;
	D_8376 : int  := +00000;
	D_8377 : int  := +00000;
	D_8378 : word := B#(  1,  1);	// State (1)
	D_8379 : word := B#(  0,  1);	//
	D_8380 : word := B#(  13,  0);	//
	D_8381 : int  := +00000;	//
	D_8382 : word := 2#0000000000000000;	//
	D_8383 : word := B#(  0,  0);	//
	D_8384 : word := B#(  1,  1);	// State (2)
	D_8385 : word := B#(  0,  0);	//
	D_8386 : word := B#(  0,  0);	//
	D_8387 : int  := +00000;	//
	D_8388 : word := 2#0000000000000000;	//
	D_8389 : word := B#(  0,  0);	//
	D_8390 : word := B#(  10,  10);	// State (3)
	D_8391 : word := B#(  0,  1);	//
	D_8392 : word := B#(  6,  1);	//
	D_8393 : int  := +00000;	//
	D_8394 : word := 2#0000000000000000;	//
	D_8395 : word := B#(  0,  0);	//
	D_8396 : word := B#(  10,  10);	// State (4)
	D_8397 : word := B#(  0,  1);	//
	D_8398 : word := B#(  7,  1);	//
	D_8399 : int  := +00203;	//
	D_8400 : word := 2#0000000000000000;	//
	D_8401 : word := B#(  0,  0);	//
	D_8402 : word := B#(  10,  10);	// State (5)
	D_8403 : word := B#(  0,  1);	//
	D_8404 : word := B#(  8,  1);	//
	D_8405 : int  := +00203;	//
	D_8406 : word := 2#0000000000000000;	//
	D_8407 : word := B#(  0,  0);	//
	D_8408 : word := B#(  1,  1);	// State (16)
	D_8409 : word := B#(  0,  1);	//
	D_8410 : word := B#(  15,  12);	//
	D_8411 : int  := +00203;	//
	D_8412 : word := 2#0000000000000000;	//
	D_8413 : word := B#(  0,  0);	//
	D_8414 : real := 0.000000000000;	//
	D_8415 : real := 65.000000000000;	//
	D_8416 : real := 0.325000000000;	//
	D_8417 : real := 0.650000000000;	//
	D_8418 : real := +0.0;	//
	D_8419 : int  := 00000;	//
	D_8420 : int  := 00000;	//
	D_8421 : word  := B#(001,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_8422 : int  := 00000;	//
	D_8423 : int  := +00000;	//
	D_8424 : word  := B#(000,000);	//
	D_8425 : int  := +00000;	//
	D_8426 : real := 62.500000000000;	// Limit (1)
	D_8427 : real := +0.0;	//
	D_8428 : int  := +00000;	//
	D_8429 : word := 2#0000000000000000;	//
	D_8430 : int := +00000;	//
	D_8431 : real := 57.500000000000;	// Limit (2)
	D_8432 : real := +0.0;	//
	D_8433 : int  := +00000;	//
	D_8434 : word := 2#0000000000000000;	//
	D_8435 : int := +00000;	//
	D_8436 : real := 56.000000000000;	// Limit (3)
	D_8437 : real := +0.0;	//
	D_8438 : int  := +00000;	//
	D_8439 : word := 2#0000000000000000;	//
	D_8440 : int := +00000;	//
	D_8441 : real := 55.000000000000;	// Limit (4)
	D_8442 : real := +0.0;	//
	D_8443 : int  := +00000;	//
	D_8444 : word := 2#0000000000000000;	//
	D_8445 : int := +00000;	//
	D_8446 : word := B#(  2,  6);	//  050301 ( 02646 )
	D_8447 : word := 2#0000000000000100;	// GEN 3 VOLTAJE L1-L2
	D_8448 : real := +0.0;
	D_8449 : word := 2#0000000000000000;
	D_8450 : int  := +00048;
	D_8451 : int  := +00000;
	D_8452 : int  := +00000;
	D_8453 : word := B#(  0, 0);
	D_8454 : word := B#(000,000);
	D_8455 : word := 2#0000000000000000;
	D_8456 : int  := +00000;
	D_8457 : int  := +00000;
	D_8458 : word := B#(  5,  5);	// State (1)
	D_8459 : word := B#(  0,  1);	//
	D_8460 : word := B#(  14,  0);	//
	D_8461 : int  := +00000;	//
	D_8462 : word := 2#0000000000000000;	//
	D_8463 : word := B#(  0,  0);	//
	D_8464 : word := B#(  5,  5);	// State (2)
	D_8465 : word := B#(  0,  1);	//
	D_8466 : word := B#(  13,  0);	//
	D_8467 : int  := +00000;	//
	D_8468 : word := 2#0000000000000000;	//
	D_8469 : word := B#(  0,  0);	//
	D_8470 : word := B#(  5,  5);	// State (3)
	D_8471 : word := B#(  0,  1);	//
	D_8472 : word := B#(  12,  0);	//
	D_8473 : int  := +00000;	//
	D_8474 : word := 2#0000000000000000;	//
	D_8475 : word := B#(  0,  0);	//
	D_8476 : word := B#(  5,  5);	// State (4)
	D_8477 : word := B#(  0,  0);	//
	D_8478 : word := B#(  0,  0);	//
	D_8479 : int  := +00000;	//
	D_8480 : word := 2#0000000000000000;	//
	D_8481 : word := B#(  0,  0);	//
	D_8482 : word := B#(  10,  10);	// State (5)
	D_8483 : word := B#(  0,  1);	//
	D_8484 : word := B#(  3,  5);	//
	D_8485 : int  := +00204;	//
	D_8486 : word := 2#0000000000000000;	//
	D_8487 : word := B#(  0,  0);	//
	D_8488 : word := B#(  10,  10);	// State (6)
	D_8489 : word := B#(  0,  1);	//
	D_8490 : word := B#(  8,  1);	//
	D_8491 : int  := +00204;	//
	D_8492 : word := 2#0000000000000000;	//
	D_8493 : word := B#(  0,  0);	//
	D_8494 : word := B#(  5,  5);	// State (16)
	D_8495 : word := B#(  0,  1);	//
	D_8496 : word := B#(  15,  12);	//
	D_8497 : int  := +00204;	//
	D_8498 : word := 2#0000000000000000;	//
	D_8499 : word := B#(  0,  0);	//
	D_8500 : real := 0.000000000000;	//
	D_8501 : real := 600.000000000000;	//
	D_8502 : real := 6.000000000000;	//
	D_8503 : real := 6.000000000000;	//
	D_8504 : real := +0.0;	//
	D_8505 : int  := 00000;	//
	D_8506 : int  := 00000;	//
	D_8507 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_8508 : int  := 00000;	//
	D_8509 : int  := +00000;	//
	D_8510 : word  := B#(000,000);	//
	D_8511 : int  := +00000;	//
	D_8512 : real := 480.000000000000;	// Limit (1)
	D_8513 : real := +0.0;	//
	D_8514 : int  := +00000;	//
	D_8515 : word := 2#0000000000000000;	//
	D_8516 : int := +00000;	//
	D_8517 : real := 470.000000000000;	// Limit (2)
	D_8518 : real := +0.0;	//
	D_8519 : int  := +00000;	//
	D_8520 : word := 2#0000000000000000;	//
	D_8521 : int := +00000;	//
	D_8522 : real := 460.000000000000;	// Limit (3)
	D_8523 : real := +0.0;	//
	D_8524 : int  := +00000;	//
	D_8525 : word := 2#0000000000000000;	//
	D_8526 : int := +00000;	//
	D_8527 : real := 420.000000000000;	// Limit (4)
	D_8528 : real := +0.0;	//
	D_8529 : int  := +00000;	//
	D_8530 : word := 2#0000000000000000;	//
	D_8531 : int := +00000;	//
	D_8532 : real := 400.000000000000;	// Limit (5)
	D_8533 : real := +0.0;	//
	D_8534 : int  := +00000;	//
	D_8535 : word := 2#0000000000000000;	//
	D_8536 : int := +00000;	//
	D_8537 : word := B#(  2,  6);	//  050302 ( 02647 )
	D_8538 : word := 2#0000000000000100;	// GEN 3 VOLTAJE L1-L3
	D_8539 : real := +0.0;
	D_8540 : word := 2#0000000000000000;
	D_8541 : int  := +00048;
	D_8542 : int  := +00000;
	D_8543 : int  := +00000;
	D_8544 : word := B#(  0, 0);
	D_8545 : word := B#(000,000);
	D_8546 : word := 2#0000000000000000;
	D_8547 : int  := +00000;
	D_8548 : int  := +00000;
	D_8549 : word := B#(  5,  5);	// State (1)
	D_8550 : word := B#(  0,  1);	//
	D_8551 : word := B#(  14,  0);	//
	D_8552 : int  := +00000;	//
	D_8553 : word := 2#0000000000000000;	//
	D_8554 : word := B#(  0,  0);	//
	D_8555 : word := B#(  5,  5);	// State (2)
	D_8556 : word := B#(  0,  1);	//
	D_8557 : word := B#(  13,  0);	//
	D_8558 : int  := +00000;	//
	D_8559 : word := 2#0000000000000000;	//
	D_8560 : word := B#(  0,  0);	//
	D_8561 : word := B#(  5,  5);	// State (3)
	D_8562 : word := B#(  0,  1);	//
	D_8563 : word := B#(  12,  0);	//
	D_8564 : int  := +00000;	//
	D_8565 : word := 2#0000000000000000;	//
	D_8566 : word := B#(  0,  0);	//
	D_8567 : word := B#(  5,  5);	// State (4)
	D_8568 : word := B#(  0,  0);	//
	D_8569 : word := B#(  0,  0);	//
	D_8570 : int  := +00000;	//
	D_8571 : word := 2#0000000000000000;	//
	D_8572 : word := B#(  0,  0);	//
	D_8573 : word := B#(  10,  10);	// State (5)
	D_8574 : word := B#(  0,  1);	//
	D_8575 : word := B#(  3,  5);	//
	D_8576 : int  := +00204;	//
	D_8577 : word := 2#0000000000000000;	//
	D_8578 : word := B#(  0,  0);	//
	D_8579 : word := B#(  10,  10);	// State (6)
	D_8580 : word := B#(  0,  1);	//
	D_8581 : word := B#(  8,  1);	//
	D_8582 : int  := +00204;	//
	D_8583 : word := 2#0000000000000000;	//
	D_8584 : word := B#(  0,  0);	//
	D_8585 : word := B#(  5,  5);	// State (16)
	D_8586 : word := B#(  0,  1);	//
	D_8587 : word := B#(  15,  12);	//
	D_8588 : int  := +00204;	//
	D_8589 : word := 2#0000000000000000;	//
	D_8590 : word := B#(  0,  0);	//
	D_8591 : real := 0.000000000000;	//
	D_8592 : real := 600.000000000000;	//
	D_8593 : real := 6.000000000000;	//
	D_8594 : real := 6.000000000000;	//
	D_8595 : real := +0.0;	//
	D_8596 : int  := 00000;	//
	D_8597 : int  := 00000;	//
	D_8598 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_8599 : int  := 00000;	//
	D_8600 : int  := +00000;	//
	D_8601 : word  := B#(000,000);	//
	D_8602 : int  := +00000;	//
	D_8603 : real := 480.000000000000;	// Limit (1)
	D_8604 : real := +0.0;	//
	D_8605 : int  := +00000;	//
	D_8606 : word := 2#0000000000000000;	//
	D_8607 : int := +00000;	//
	D_8608 : real := 470.000000000000;	// Limit (2)
	D_8609 : real := +0.0;	//
	D_8610 : int  := +00000;	//
	D_8611 : word := 2#0000000000000000;	//
	D_8612 : int := +00000;	//
	D_8613 : real := 460.000000000000;	// Limit (3)
	D_8614 : real := +0.0;	//
	D_8615 : int  := +00000;	//
	D_8616 : word := 2#0000000000000000;	//
	D_8617 : int := +00000;	//
	D_8618 : real := 420.000000000000;	// Limit (4)
	D_8619 : real := +0.0;	//
	D_8620 : int  := +00000;	//
	D_8621 : word := 2#0000000000000000;	//
	D_8622 : int := +00000;	//
	D_8623 : real := 400.000000000000;	// Limit (5)
	D_8624 : real := +0.0;	//
	D_8625 : int  := +00000;	//
	D_8626 : word := 2#0000000000000000;	//
	D_8627 : int := +00000;	//
	D_8628 : word := B#(  2,  6);	//  050303 ( 02648 )
	D_8629 : word := 2#0000000000000100;	// GEN 3 VOLTAJE L2-L3
	D_8630 : real := +0.0;
	D_8631 : word := 2#0000000000000000;
	D_8632 : int  := +00048;
	D_8633 : int  := +00000;
	D_8634 : int  := +00000;
	D_8635 : word := B#(  0, 0);
	D_8636 : word := B#(000,000);
	D_8637 : word := 2#0000000000000000;
	D_8638 : int  := +00000;
	D_8639 : int  := +00000;
	D_8640 : word := B#(  5,  5);	// State (1)
	D_8641 : word := B#(  0,  1);	//
	D_8642 : word := B#(  14,  0);	//
	D_8643 : int  := +00000;	//
	D_8644 : word := 2#0000000000000000;	//
	D_8645 : word := B#(  0,  0);	//
	D_8646 : word := B#(  5,  5);	// State (2)
	D_8647 : word := B#(  0,  1);	//
	D_8648 : word := B#(  13,  0);	//
	D_8649 : int  := +00000;	//
	D_8650 : word := 2#0000000000000000;	//
	D_8651 : word := B#(  0,  0);	//
	D_8652 : word := B#(  5,  5);	// State (3)
	D_8653 : word := B#(  0,  1);	//
	D_8654 : word := B#(  12,  0);	//
	D_8655 : int  := +00000;	//
	D_8656 : word := 2#0000000000000000;	//
	D_8657 : word := B#(  0,  0);	//
	D_8658 : word := B#(  5,  5);	// State (4)
	D_8659 : word := B#(  0,  0);	//
	D_8660 : word := B#(  0,  0);	//
	D_8661 : int  := +00000;	//
	D_8662 : word := 2#0000000000000000;	//
	D_8663 : word := B#(  0,  0);	//
	D_8664 : word := B#(  10,  10);	// State (5)
	D_8665 : word := B#(  0,  1);	//
	D_8666 : word := B#(  3,  5);	//
	D_8667 : int  := +00204;	//
	D_8668 : word := 2#0000000000000000;	//
	D_8669 : word := B#(  0,  0);	//
	D_8670 : word := B#(  10,  10);	// State (6)
	D_8671 : word := B#(  0,  1);	//
	D_8672 : word := B#(  8,  1);	//
	D_8673 : int  := +00204;	//
	D_8674 : word := 2#0000000000000000;	//
	D_8675 : word := B#(  0,  0);	//
	D_8676 : word := B#(  5,  5);	// State (16)
	D_8677 : word := B#(  0,  1);	//
	D_8678 : word := B#(  15,  12);	//
	D_8679 : int  := +00204;	//
	D_8680 : word := 2#0000000000000000;	//
	D_8681 : word := B#(  0,  0);	//
	D_8682 : real := 0.000000000000;	//
	D_8683 : real := 600.000000000000;	//
	D_8684 : real := 6.000000000000;	//
	D_8685 : real := 6.000000000000;	//
	D_8686 : real := +0.0;	//
	D_8687 : int  := 00000;	//
	D_8688 : int  := 00000;	//
	D_8689 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_8690 : int  := 00000;	//
	D_8691 : int  := +00000;	//
	D_8692 : word  := B#(000,000);	//
	D_8693 : int  := +00000;	//
	D_8694 : real := 480.000000000000;	// Limit (1)
	D_8695 : real := +0.0;	//
	D_8696 : int  := +00000;	//
	D_8697 : word := 2#0000000000000000;	//
	D_8698 : int := +00000;	//
	D_8699 : real := 470.000000000000;	// Limit (2)
	D_8700 : real := +0.0;	//
	D_8701 : int  := +00000;	//
	D_8702 : word := 2#0000000000000000;	//
	D_8703 : int := +00000;	//
	D_8704 : real := 460.000000000000;	// Limit (3)
	D_8705 : real := +0.0;	//
	D_8706 : int  := +00000;	//
	D_8707 : word := 2#0000000000000000;	//
	D_8708 : int := +00000;	//
	D_8709 : real := 420.000000000000;	// Limit (4)
	D_8710 : real := +0.0;	//
	D_8711 : int  := +00000;	//
	D_8712 : word := 2#0000000000000000;	//
	D_8713 : int := +00000;	//
	D_8714 : real := 400.000000000000;	// Limit (5)
	D_8715 : real := +0.0;	//
	D_8716 : int  := +00000;	//
	D_8717 : word := 2#0000000000000000;	//
	D_8718 : int := +00000;	//
	D_8719 : word := B#(  2,  1);	//  050304 ( 02649 )
	D_8720 : word := 2#0000000000000100;	// GEN 3 CORRIENTE L1
	D_8721 : real := +0.0;
	D_8722 : word := 2#0000000000000000;
	D_8723 : int  := +00000;
	D_8724 : int  := +00000;
	D_8725 : int  := +00000;
	D_8726 : word := B#(  0, 0);
	D_8727 : word := B#(000,000);
	D_8728 : word := 2#0000000000000000;
	D_8729 : int  := +00000;
	D_8730 : int  := +00000;
	D_8731 : word := B#(  1,  1);	// State (1)
	D_8732 : word := B#(  0,  0);	//
	D_8733 : word := B#(  0,  0);	//
	D_8734 : int  := +00000;	//
	D_8735 : word := 2#0000000000000000;	//
	D_8736 : word := B#(  0,  0);	//
	D_8737 : word := B#(  1,  1);	// State (16)
	D_8738 : word := B#(  0,  1);	//
	D_8739 : word := B#(  15,  12);	//
	D_8740 : int  := +00000;	//
	D_8741 : word := 2#0000000000000000;	//
	D_8742 : word := B#(  0,  0);	//
	D_8743 : real := 0.000000000000;	//
	D_8744 : real := 500.000000000000;	//
	D_8745 : real := 5.000000000000;	//
	D_8746 : real := 5.000000000000;	//
	D_8747 : real := +0.0;	//
	D_8748 : int  := 00000;	//
	D_8749 : int  := 00000;	//
	D_8750 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_8751 : int  := 00000;	//
	D_8752 : int  := +00000;	//
	D_8753 : word  := B#(000,000);	//
	D_8754 : int  := +00000;	//
	D_8755 : word := B#(  2,  1);	//  050305 ( 02650 )
	D_8756 : word := 2#0000000000000100;	// GEN 3 CORRIENTE L2
	D_8757 : real := +0.0;
	D_8758 : word := 2#0000000000000000;
	D_8759 : int  := +00000;
	D_8760 : int  := +00000;
	D_8761 : int  := +00000;
	D_8762 : word := B#(  0, 0);
	D_8763 : word := B#(000,000);
	D_8764 : word := 2#0000000000000000;
	D_8765 : int  := +00000;
	D_8766 : int  := +00000;
	D_8767 : word := B#(  1,  1);	// State (1)
	D_8768 : word := B#(  0,  0);	//
	D_8769 : word := B#(  0,  0);	//
	D_8770 : int  := +00000;	//
	D_8771 : word := 2#0000000000000000;	//
	D_8772 : word := B#(  0,  0);	//
	D_8773 : word := B#(  1,  1);	// State (16)
	D_8774 : word := B#(  0,  1);	//
	D_8775 : word := B#(  15,  12);	//
	D_8776 : int  := +00000;	//
	D_8777 : word := 2#0000000000000000;	//
	D_8778 : word := B#(  0,  0);	//
	D_8779 : real := 0.000000000000;	//
	D_8780 : real := 500.000000000000;	//
	D_8781 : real := 5.000000000000;	//
	D_8782 : real := 5.000000000000;	//
	D_8783 : real := +0.0;	//
	D_8784 : int  := 00000;	//
	D_8785 : int  := 00000;	//
	D_8786 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_8787 : int  := 00000;	//
	D_8788 : int  := +00000;	//
	D_8789 : word  := B#(000,000);	//
	D_8790 : int  := +00000;	//
	D_8791 : word := B#(  2,  1);	//  050306 ( 02651 )
	D_8792 : word := 2#0000000000000100;	// GEN 3 CORRIENTE L3
	D_8793 : real := +0.0;
	D_8794 : word := 2#0000000000000000;
	D_8795 : int  := +00000;
	D_8796 : int  := +00000;
	D_8797 : int  := +00000;
	D_8798 : word := B#(  0, 0);
	D_8799 : word := B#(000,000);
	D_8800 : word := 2#0000000000000000;
	D_8801 : int  := +00000;
	D_8802 : int  := +00000;
	D_8803 : word := B#(  1,  1);	// State (1)
	D_8804 : word := B#(  0,  0);	//
	D_8805 : word := B#(  0,  0);	//
	D_8806 : int  := +00000;	//
	D_8807 : word := 2#0000000000000000;	//
	D_8808 : word := B#(  0,  0);	//
	D_8809 : word := B#(  1,  1);	// State (16)
	D_8810 : word := B#(  0,  1);	//
	D_8811 : word := B#(  15,  12);	//
	D_8812 : int  := +00000;	//
	D_8813 : word := 2#0000000000000000;	//
	D_8814 : word := B#(  0,  0);	//
	D_8815 : real := 0.000000000000;	//
	D_8816 : real := 500.000000000000;	//
	D_8817 : real := 5.000000000000;	//
	D_8818 : real := 5.000000000000;	//
	D_8819 : real := +0.0;	//
	D_8820 : int  := 00000;	//
	D_8821 : int  := 00000;	//
	D_8822 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_8823 : int  := 00000;	//
	D_8824 : int  := +00000;	//
	D_8825 : word  := B#(000,000);	//
	D_8826 : int  := +00000;	//
	D_8827 : word := B#(  2,  5);	//  050307 ( 02652 )
	D_8828 : word := 2#0000000000000100;	// GEN 3 POTENCIA KW
	D_8829 : real := +0.0;
	D_8830 : word := 2#0000000000000000;
	D_8831 : int  := +00000;
	D_8832 : int  := +00000;
	D_8833 : int  := +00000;
	D_8834 : word := B#(  0, 0);
	D_8835 : word := B#(000,000);
	D_8836 : word := 2#0000000000000000;
	D_8837 : int  := +00000;
	D_8838 : int  := +00000;
	D_8839 : word := B#(  1,  1);	// State (1)
	D_8840 : word := B#(  0,  1);	//
	D_8841 : word := B#(  14,  0);	//
	D_8842 : int  := +00000;	//
	D_8843 : word := 2#0000000000000000;	//
	D_8844 : word := B#(  0,  0);	//
	D_8845 : word := B#(  1,  1);	// State (2)
	D_8846 : word := B#(  0,  1);	//
	D_8847 : word := B#(  13,  0);	//
	D_8848 : int  := +00000;	//
	D_8849 : word := 2#0000000000000000;	//
	D_8850 : word := B#(  0,  0);	//
	D_8851 : word := B#(  1,  1);	// State (3)
	D_8852 : word := B#(  0,  1);	//
	D_8853 : word := B#(  12,  0);	//
	D_8854 : int  := +00000;	//
	D_8855 : word := 2#0000000000000000;	//
	D_8856 : word := B#(  0,  0);	//
	D_8857 : word := B#(  1,  1);	// State (4)
	D_8858 : word := B#(  0,  0);	//
	D_8859 : word := B#(  0,  0);	//
	D_8860 : int  := +00000;	//
	D_8861 : word := 2#0000000000000000;	//
	D_8862 : word := B#(  0,  0);	//
	D_8863 : word := B#(  1,  1);	// State (5)
	D_8864 : word := B#(  0,  1);	//
	D_8865 : word := B#(  8,  1);	//
	D_8866 : int  := +00000;	//
	D_8867 : word := 2#0000000000000000;	//
	D_8868 : word := B#(  0,  0);	//
	D_8869 : word := B#(  1,  1);	// State (16)
	D_8870 : word := B#(  0,  1);	//
	D_8871 : word := B#(  15,  12);	//
	D_8872 : int  := +00000;	//
	D_8873 : word := 2#0000000000000000;	//
	D_8874 : word := B#(  0,  0);	//
	D_8875 : real := -20.000000000000;	//
	D_8876 : real := 100.000000000000;	//
	D_8877 : real := 1.200000000000;	//
	D_8878 : real := 1.200000000000;	//
	D_8879 : real := +0.0;	//
	D_8880 : int  := 00000;	//
	D_8881 : int  := 00000;	//
	D_8882 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_8883 : int  := 00000;	//
	D_8884 : int  := +00000;	//
	D_8885 : word  := B#(000,000);	//
	D_8886 : int  := +00000;	//
	D_8887 : real := 100.000000000000;	// Limit (1)
	D_8888 : real := +0.0;	//
	D_8889 : int  := +00000;	//
	D_8890 : word := 2#0000000000000000;	//
	D_8891 : int := +00000;	//
	D_8892 : real := 90.000000000000;	// Limit (2)
	D_8893 : real := +0.0;	//
	D_8894 : int  := +00000;	//
	D_8895 : word := 2#0000000000000000;	//
	D_8896 : int := +00000;	//
	D_8897 : real := 80.000000000000;	// Limit (3)
	D_8898 : real := +0.0;	//
	D_8899 : int  := +00000;	//
	D_8900 : word := 2#0000000000000000;	//
	D_8901 : int := +00000;	//
	D_8902 : real := -7.000000000000;	// Limit (4)
	D_8903 : real := +0.0;	//
	D_8904 : int  := +00000;	//
	D_8905 : word := 2#0000000000000000;	//
	D_8906 : int := +00000;	//
	D_8907 : word := B#(  2,  1);	//  050308 ( 02653 )
	D_8908 : word := 2#0000000000000100;	// GEN 3 FACTOR DE POTENCIA
	D_8909 : real := +0.0;
	D_8910 : word := 2#0000000000000000;
	D_8911 : int  := +00000;
	D_8912 : int  := +00000;
	D_8913 : int  := +00000;
	D_8914 : word := B#(  0, 0);
	D_8915 : word := B#(000,000);
	D_8916 : word := 2#0000000000000000;
	D_8917 : int  := +00000;
	D_8918 : int  := +00000;
	D_8919 : word := B#(  1,  1);	// State (1)
	D_8920 : word := B#(  0,  0);	//
	D_8921 : word := B#(  0,  0);	//
	D_8922 : int  := +00000;	//
	D_8923 : word := 2#0000000000000000;	//
	D_8924 : word := B#(  0,  0);	//
	D_8925 : word := B#(  1,  1);	// State (16)
	D_8926 : word := B#(  0,  1);	//
	D_8927 : word := B#(  15,  12);	//
	D_8928 : int  := +00000;	//
	D_8929 : word := 2#0000000000000000;	//
	D_8930 : word := B#(  0,  0);	//
	D_8931 : real := -1.000000000000;	//
	D_8932 : real := 1.000000000000;	//
	D_8933 : real := 0.020000000000;	//
	D_8934 : real := 0.020000000000;	//
	D_8935 : real := +0.0;	//
	D_8936 : int  := 00000;	//
	D_8937 : int  := 00000;	//
	D_8938 : word  := B#(002,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_8939 : int  := 00000;	//
	D_8940 : int  := +00000;	//
	D_8941 : word  := B#(000,000);	//
	D_8942 : int  := +00000;	//
	D_8943 : word := B#(  2,  1);	//  050309 ( 02654 )
	D_8944 : word := 2#0000000000000100;	// GEN 3 POTENCIA REACTIVE KVAR
	D_8945 : real := +0.0;
	D_8946 : word := 2#0000000000000000;
	D_8947 : int  := +00000;
	D_8948 : int  := +00000;
	D_8949 : int  := +00000;
	D_8950 : word := B#(  0, 0);
	D_8951 : word := B#(000,000);
	D_8952 : word := 2#0000000000000000;
	D_8953 : int  := +00000;
	D_8954 : int  := +00000;
	D_8955 : word := B#(  1,  1);	// State (1)
	D_8956 : word := B#(  0,  0);	//
	D_8957 : word := B#(  0,  0);	//
	D_8958 : int  := +00000;	//
	D_8959 : word := 2#0000000000000000;	//
	D_8960 : word := B#(  0,  0);	//
	D_8961 : word := B#(  1,  1);	// State (16)
	D_8962 : word := B#(  0,  1);	//
	D_8963 : word := B#(  15,  12);	//
	D_8964 : int  := +00000;	//
	D_8965 : word := 2#0000000000000000;	//
	D_8966 : word := B#(  0,  0);	//
	D_8967 : real := 0.000000000000;	//
	D_8968 : real := 150.000000000000;	//
	D_8969 : real := 1.500000000000;	//
	D_8970 : real := 1.500000000000;	//
	D_8971 : real := +0.0;	//
	D_8972 : int  := 00000;	//
	D_8973 : int  := 00000;	//
	D_8974 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_8975 : int  := 00000;	//
	D_8976 : int  := +00000;	//
	D_8977 : word  := B#(000,000);	//
	D_8978 : int  := +00000;	//
	D_8979 : word := B#(  2,  5);	//  050315 ( 02655 )
	D_8980 : word := 2#0000000000000100;	// GEN 3 FRECUENCIA
	D_8981 : real := +0.0;
	D_8982 : word := 2#0000000000000000;
	D_8983 : int  := +00024;
	D_8984 : int  := +00000;
	D_8985 : int  := +00000;
	D_8986 : word := B#(  0, 0);
	D_8987 : word := B#(000,000);
	D_8988 : word := 2#0000000000000000;
	D_8989 : int  := +00000;
	D_8990 : int  := +00000;
	D_8991 : word := B#(  1,  1);	// State (1)
	D_8992 : word := B#(  0,  1);	//
	D_8993 : word := B#(  13,  0);	//
	D_8994 : int  := +00000;	//
	D_8995 : word := 2#0000000000000000;	//
	D_8996 : word := B#(  0,  0);	//
	D_8997 : word := B#(  1,  1);	// State (2)
	D_8998 : word := B#(  0,  0);	//
	D_8999 : word := B#(  0,  0);	//
	D_9000 : int  := +00000;	//
	D_9001 : word := 2#0000000000000000;	//
	D_9002 : word := B#(  0,  0);	//
	D_9003 : word := B#(  10,  10);	// State (3)
	D_9004 : word := B#(  0,  1);	//
	D_9005 : word := B#(  6,  1);	//
	D_9006 : int  := +00000;	//
	D_9007 : word := 2#0000000000000000;	//
	D_9008 : word := B#(  0,  0);	//
	D_9009 : word := B#(  10,  10);	// State (4)
	D_9010 : word := B#(  0,  1);	//
	D_9011 : word := B#(  7,  1);	//
	D_9012 : int  := +00204;	//
	D_9013 : word := 2#0000000000000000;	//
	D_9014 : word := B#(  0,  0);	//
	D_9015 : word := B#(  10,  10);	// State (5)
	D_9016 : word := B#(  0,  1);	//
	D_9017 : word := B#(  8,  1);	//
	D_9018 : int  := +00204;	//
	D_9019 : word := 2#0000000000000000;	//
	D_9020 : word := B#(  0,  0);	//
	D_9021 : word := B#(  1,  1);	// State (16)
	D_9022 : word := B#(  0,  1);	//
	D_9023 : word := B#(  15,  12);	//
	D_9024 : int  := +00204;	//
	D_9025 : word := 2#0000000000000000;	//
	D_9026 : word := B#(  0,  0);	//
	D_9027 : real := 0.000000000000;	//
	D_9028 : real := 65.000000000000;	//
	D_9029 : real := 0.325000000000;	//
	D_9030 : real := 0.650000000000;	//
	D_9031 : real := +0.0;	//
	D_9032 : int  := 00000;	//
	D_9033 : int  := 00000;	//
	D_9034 : word  := B#(001,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_9035 : int  := 00000;	//
	D_9036 : int  := +00000;	//
	D_9037 : word  := B#(000,000);	//
	D_9038 : int  := +00000;	//
	D_9039 : real := 62.500000000000;	// Limit (1)
	D_9040 : real := +0.0;	//
	D_9041 : int  := +00000;	//
	D_9042 : word := 2#0000000000000000;	//
	D_9043 : int := +00000;	//
	D_9044 : real := 57.500000000000;	// Limit (2)
	D_9045 : real := +0.0;	//
	D_9046 : int  := +00000;	//
	D_9047 : word := 2#0000000000000000;	//
	D_9048 : int := +00000;	//
	D_9049 : real := 56.000000000000;	// Limit (3)
	D_9050 : real := +0.0;	//
	D_9051 : int  := +00000;	//
	D_9052 : word := 2#0000000000000000;	//
	D_9053 : int := +00000;	//
	D_9054 : real := 55.000000000000;	// Limit (4)
	D_9055 : real := +0.0;	//
	D_9056 : int  := +00000;	//
	D_9057 : word := 2#0000000000000000;	//
	D_9058 : int := +00000;	//
	D_9059 : word := B#(  2,  6);	//  050401 ( 02656 )
	D_9060 : word := 2#0000000000000100;	// SP VOLTAJE L1-L2
	D_9061 : real := +0.0;
	D_9062 : word := 2#0000000000000000;
	D_9063 : int  := +00048;
	D_9064 : int  := +00000;
	D_9065 : int  := +00000;
	D_9066 : word := B#(  0, 0);
	D_9067 : word := B#(000,000);
	D_9068 : word := 2#0000000000000000;
	D_9069 : int  := +00000;
	D_9070 : int  := +00000;
	D_9071 : word := B#(  5,  5);	// State (1)
	D_9072 : word := B#(  0,  1);	//
	D_9073 : word := B#(  14,  0);	//
	D_9074 : int  := +00000;	//
	D_9075 : word := 2#0000000000000000;	//
	D_9076 : word := B#(  0,  0);	//
	D_9077 : word := B#(  5,  5);	// State (2)
	D_9078 : word := B#(  0,  1);	//
	D_9079 : word := B#(  13,  0);	//
	D_9080 : int  := +00000;	//
	D_9081 : word := 2#0000000000000000;	//
	D_9082 : word := B#(  0,  0);	//
	D_9083 : word := B#(  5,  5);	// State (3)
	D_9084 : word := B#(  0,  1);	//
	D_9085 : word := B#(  12,  0);	//
	D_9086 : int  := +00000;	//
	D_9087 : word := 2#0000000000000000;	//
	D_9088 : word := B#(  0,  0);	//
	D_9089 : word := B#(  5,  5);	// State (4)
	D_9090 : word := B#(  0,  0);	//
	D_9091 : word := B#(  0,  0);	//
	D_9092 : int  := +00000;	//
	D_9093 : word := 2#0000000000000000;	//
	D_9094 : word := B#(  0,  0);	//
	D_9095 : word := B#(  5,  5);	// State (5)
	D_9096 : word := B#(  0,  1);	//
	D_9097 : word := B#(  3,  5);	//
	D_9098 : int  := +00205;	//
	D_9099 : word := 2#0000000000000000;	//
	D_9100 : word := B#(  0,  0);	//
	D_9101 : word := B#(  5,  5);	// State (6)
	D_9102 : word := B#(  0,  1);	//
	D_9103 : word := B#(  8,  1);	//
	D_9104 : int  := +00205;	//
	D_9105 : word := 2#0000000000000000;	//
	D_9106 : word := B#(  0,  0);	//
	D_9107 : word := B#(  5,  5);	// State (16)
	D_9108 : word := B#(  0,  1);	//
	D_9109 : word := B#(  15,  12);	//
	D_9110 : int  := +00205;	//
	D_9111 : word := 2#0000000000000000;	//
	D_9112 : word := B#(  0,  0);	//
	D_9113 : real := 0.000000000000;	//
	D_9114 : real := 600.000000000000;	//
	D_9115 : real := 6.000000000000;	//
	D_9116 : real := 6.000000000000;	//
	D_9117 : real := +0.0;	//
	D_9118 : int  := 00000;	//
	D_9119 : int  := 00000;	//
	D_9120 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_9121 : int  := 00000;	//
	D_9122 : int  := +00000;	//
	D_9123 : word  := B#(000,000);	//
	D_9124 : int  := +00000;	//
	D_9125 : real := 480.000000000000;	// Limit (1)
	D_9126 : real := +0.0;	//
	D_9127 : int  := +00000;	//
	D_9128 : word := 2#0000000000000000;	//
	D_9129 : int := +00000;	//
	D_9130 : real := 470.000000000000;	// Limit (2)
	D_9131 : real := +0.0;	//
	D_9132 : int  := +00000;	//
	D_9133 : word := 2#0000000000000000;	//
	D_9134 : int := +00000;	//
	D_9135 : real := 460.000000000000;	// Limit (3)
	D_9136 : real := +0.0;	//
	D_9137 : int  := +00000;	//
	D_9138 : word := 2#0000000000000000;	//
	D_9139 : int := +00000;	//
	D_9140 : real := 420.000000000000;	// Limit (4)
	D_9141 : real := +0.0;	//
	D_9142 : int  := +00000;	//
	D_9143 : word := 2#0000000000000000;	//
	D_9144 : int := +00000;	//
	D_9145 : real := 400.000000000000;	// Limit (5)
	D_9146 : real := +0.0;	//
	D_9147 : int  := +00000;	//
	D_9148 : word := 2#0000000000000000;	//
	D_9149 : int := +00000;	//
	D_9150 : word := B#(  2,  6);	//  050402 ( 02657 )
	D_9151 : word := 2#0000000000000100;	// SP VOLTAJE L1-L3
	D_9152 : real := +0.0;
	D_9153 : word := 2#0000000000000000;
	D_9154 : int  := +00048;
	D_9155 : int  := +00000;
	D_9156 : int  := +00000;
	D_9157 : word := B#(  0, 0);
	D_9158 : word := B#(000,000);
	D_9159 : word := 2#0000000000000000;
	D_9160 : int  := +00000;
	D_9161 : int  := +00000;
	D_9162 : word := B#(  5,  5);	// State (1)
	D_9163 : word := B#(  0,  1);	//
	D_9164 : word := B#(  14,  0);	//
	D_9165 : int  := +00000;	//
	D_9166 : word := 2#0000000000000000;	//
	D_9167 : word := B#(  0,  0);	//
	D_9168 : word := B#(  5,  5);	// State (2)
	D_9169 : word := B#(  0,  1);	//
	D_9170 : word := B#(  13,  0);	//
	D_9171 : int  := +00000;	//
	D_9172 : word := 2#0000000000000000;	//
	D_9173 : word := B#(  0,  0);	//
	D_9174 : word := B#(  5,  5);	// State (3)
	D_9175 : word := B#(  0,  1);	//
	D_9176 : word := B#(  12,  0);	//
	D_9177 : int  := +00000;	//
	D_9178 : word := 2#0000000000000000;	//
	D_9179 : word := B#(  0,  0);	//
	D_9180 : word := B#(  5,  5);	// State (4)
	D_9181 : word := B#(  0,  0);	//
	D_9182 : word := B#(  0,  0);	//
	D_9183 : int  := +00000;	//
	D_9184 : word := 2#0000000000000000;	//
	D_9185 : word := B#(  0,  0);	//
	D_9186 : word := B#(  5,  5);	// State (5)
	D_9187 : word := B#(  0,  1);	//
	D_9188 : word := B#(  3,  5);	//
	D_9189 : int  := +00205;	//
	D_9190 : word := 2#0000000000000000;	//
	D_9191 : word := B#(  0,  0);	//
	D_9192 : word := B#(  5,  5);	// State (6)
	D_9193 : word := B#(  0,  1);	//
	D_9194 : word := B#(  8,  1);	//
	D_9195 : int  := +00205;	//
	D_9196 : word := 2#0000000000000000;	//
	D_9197 : word := B#(  0,  0);	//
	D_9198 : word := B#(  5,  5);	// State (16)
	D_9199 : word := B#(  0,  1);	//
	D_9200 : word := B#(  15,  12);	//
	D_9201 : int  := +00205;	//
	D_9202 : word := 2#0000000000000000;	//
	D_9203 : word := B#(  0,  0);	//
	D_9204 : real := 0.000000000000;	//
	D_9205 : real := 600.000000000000;	//
	D_9206 : real := 6.000000000000;	//
	D_9207 : real := 6.000000000000;	//
	D_9208 : real := +0.0;	//
	D_9209 : int  := 00000;	//
	D_9210 : int  := 00000;	//
	D_9211 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_9212 : int  := 00000;	//
	D_9213 : int  := +00000;	//
	D_9214 : word  := B#(000,000);	//
	D_9215 : int  := +00000;	//
	D_9216 : real := 480.000000000000;	// Limit (1)
	D_9217 : real := +0.0;	//
	D_9218 : int  := +00000;	//
	D_9219 : word := 2#0000000000000000;	//
	D_9220 : int := +00000;	//
	D_9221 : real := 470.000000000000;	// Limit (2)
	D_9222 : real := +0.0;	//
	D_9223 : int  := +00000;	//
	D_9224 : word := 2#0000000000000000;	//
	D_9225 : int := +00000;	//
	D_9226 : real := 460.000000000000;	// Limit (3)
	D_9227 : real := +0.0;	//
	D_9228 : int  := +00000;	//
	D_9229 : word := 2#0000000000000000;	//
	D_9230 : int := +00000;	//
	D_9231 : real := 420.000000000000;	// Limit (4)
	D_9232 : real := +0.0;	//
	D_9233 : int  := +00000;	//
	D_9234 : word := 2#0000000000000000;	//
	D_9235 : int := +00000;	//
	D_9236 : real := 400.000000000000;	// Limit (5)
	D_9237 : real := +0.0;	//
	D_9238 : int  := +00000;	//
	D_9239 : word := 2#0000000000000000;	//
	D_9240 : int := +00000;	//
	D_9241 : word := B#(  2,  6);	//  050403 ( 02658 )
	D_9242 : word := 2#0000000000000100;	// SP VOLTAJE L2-L3
	D_9243 : real := +0.0;
	D_9244 : word := 2#0000000000000000;
	D_9245 : int  := +00048;
	D_9246 : int  := +00000;
	D_9247 : int  := +00000;
	D_9248 : word := B#(  0, 0);
	D_9249 : word := B#(000,000);
	D_9250 : word := 2#0000000000000000;
	D_9251 : int  := +00000;
	D_9252 : int  := +00000;
	D_9253 : word := B#(  5,  5);	// State (1)
	D_9254 : word := B#(  0,  1);	//
	D_9255 : word := B#(  14,  0);	//
	D_9256 : int  := +00000;	//
	D_9257 : word := 2#0000000000000000;	//
	D_9258 : word := B#(  0,  0);	//
	D_9259 : word := B#(  5,  5);	// State (2)
	D_9260 : word := B#(  0,  1);	//
	D_9261 : word := B#(  13,  0);	//
	D_9262 : int  := +00000;	//
	D_9263 : word := 2#0000000000000000;	//
	D_9264 : word := B#(  0,  0);	//
	D_9265 : word := B#(  5,  5);	// State (3)
	D_9266 : word := B#(  0,  1);	//
	D_9267 : word := B#(  12,  0);	//
	D_9268 : int  := +00000;	//
	D_9269 : word := 2#0000000000000000;	//
	D_9270 : word := B#(  0,  0);	//
	D_9271 : word := B#(  5,  5);	// State (4)
	D_9272 : word := B#(  0,  0);	//
	D_9273 : word := B#(  0,  0);	//
	D_9274 : int  := +00000;	//
	D_9275 : word := 2#0000000000000000;	//
	D_9276 : word := B#(  0,  0);	//
	D_9277 : word := B#(  5,  5);	// State (5)
	D_9278 : word := B#(  0,  1);	//
	D_9279 : word := B#(  3,  5);	//
	D_9280 : int  := +00205;	//
	D_9281 : word := 2#0000000000000000;	//
	D_9282 : word := B#(  0,  0);	//
	D_9283 : word := B#(  5,  5);	// State (6)
	D_9284 : word := B#(  0,  1);	//
	D_9285 : word := B#(  8,  1);	//
	D_9286 : int  := +00205;	//
	D_9287 : word := 2#0000000000000000;	//
	D_9288 : word := B#(  0,  0);	//
	D_9289 : word := B#(  5,  5);	// State (16)
	D_9290 : word := B#(  0,  1);	//
	D_9291 : word := B#(  15,  12);	//
	D_9292 : int  := +00205;	//
	D_9293 : word := 2#0000000000000000;	//
	D_9294 : word := B#(  0,  0);	//
	D_9295 : real := 0.000000000000;	//
	D_9296 : real := 600.000000000000;	//
	D_9297 : real := 6.000000000000;	//
	D_9298 : real := 6.000000000000;	//
	D_9299 : real := +0.0;	//
	D_9300 : int  := 00000;	//
	D_9301 : int  := 00000;	//
	D_9302 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_9303 : int  := 00000;	//
	D_9304 : int  := +00000;	//
	D_9305 : word  := B#(000,000);	//
	D_9306 : int  := +00000;	//
	D_9307 : real := 480.000000000000;	// Limit (1)
	D_9308 : real := +0.0;	//
	D_9309 : int  := +00000;	//
	D_9310 : word := 2#0000000000000000;	//
	D_9311 : int := +00000;	//
	D_9312 : real := 470.000000000000;	// Limit (2)
	D_9313 : real := +0.0;	//
	D_9314 : int  := +00000;	//
	D_9315 : word := 2#0000000000000000;	//
	D_9316 : int := +00000;	//
	D_9317 : real := 460.000000000000;	// Limit (3)
	D_9318 : real := +0.0;	//
	D_9319 : int  := +00000;	//
	D_9320 : word := 2#0000000000000000;	//
	D_9321 : int := +00000;	//
	D_9322 : real := 420.000000000000;	// Limit (4)
	D_9323 : real := +0.0;	//
	D_9324 : int  := +00000;	//
	D_9325 : word := 2#0000000000000000;	//
	D_9326 : int := +00000;	//
	D_9327 : real := 400.000000000000;	// Limit (5)
	D_9328 : real := +0.0;	//
	D_9329 : int  := +00000;	//
	D_9330 : word := 2#0000000000000000;	//
	D_9331 : int := +00000;	//
	D_9332 : word := B#(  2,  1);	//  050404 ( 02659 )
	D_9333 : word := 2#0000000000000100;	// SP CORRIENTE L1
	D_9334 : real := +0.0;
	D_9335 : word := 2#0000000000000000;
	D_9336 : int  := +00000;
	D_9337 : int  := +00000;
	D_9338 : int  := +00000;
	D_9339 : word := B#(  0, 0);
	D_9340 : word := B#(000,000);
	D_9341 : word := 2#0000000000000000;
	D_9342 : int  := +00000;
	D_9343 : int  := +00000;
	D_9344 : word := B#(  1,  1);	// State (1)
	D_9345 : word := B#(  0,  0);	//
	D_9346 : word := B#(  0,  0);	//
	D_9347 : int  := +00000;	//
	D_9348 : word := 2#0000000000000000;	//
	D_9349 : word := B#(  0,  0);	//
	D_9350 : word := B#(  1,  1);	// State (16)
	D_9351 : word := B#(  0,  1);	//
	D_9352 : word := B#(  15,  12);	//
	D_9353 : int  := +00000;	//
	D_9354 : word := 2#0000000000000000;	//
	D_9355 : word := B#(  0,  0);	//
	D_9356 : real := 0.000000000000;	//
	D_9357 : real := 500.000000000000;	//
	D_9358 : real := 5.000000000000;	//
	D_9359 : real := 5.000000000000;	//
	D_9360 : real := +0.0;	//
	D_9361 : int  := 00000;	//
	D_9362 : int  := 00000;	//
	D_9363 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_9364 : int  := 00000;	//
	D_9365 : int  := +00000;	//
	D_9366 : word  := B#(000,000);	//
	D_9367 : int  := +00000;	//
	D_9368 : word := B#(  2,  1);	//  050405 ( 02660 )
	D_9369 : word := 2#0000000000000100;	// SP CORRIENTE L2
	D_9370 : real := +0.0;
	D_9371 : word := 2#0000000000000000;
	D_9372 : int  := +00000;
	D_9373 : int  := +00000;
	D_9374 : int  := +00000;
	D_9375 : word := B#(  0, 0);
	D_9376 : word := B#(000,000);
	D_9377 : word := 2#0000000000000000;
	D_9378 : int  := +00000;
	D_9379 : int  := +00000;
	D_9380 : word := B#(  1,  1);	// State (1)
	D_9381 : word := B#(  0,  0);	//
	D_9382 : word := B#(  0,  0);	//
	D_9383 : int  := +00000;	//
	D_9384 : word := 2#0000000000000000;	//
	D_9385 : word := B#(  0,  0);	//
	D_9386 : word := B#(  1,  1);	// State (16)
	D_9387 : word := B#(  0,  1);	//
	D_9388 : word := B#(  15,  12);	//
	D_9389 : int  := +00000;	//
	D_9390 : word := 2#0000000000000000;	//
	D_9391 : word := B#(  0,  0);	//
	D_9392 : real := 0.000000000000;	//
	D_9393 : real := 500.000000000000;	//
	D_9394 : real := 5.000000000000;	//
	D_9395 : real := 5.000000000000;	//
	D_9396 : real := +0.0;	//
	D_9397 : int  := 00000;	//
	D_9398 : int  := 00000;	//
	D_9399 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_9400 : int  := 00000;	//
	D_9401 : int  := +00000;	//
	D_9402 : word  := B#(000,000);	//
	D_9403 : int  := +00000;	//
	D_9404 : word := B#(  2,  1);	//  050406 ( 02661 )
	D_9405 : word := 2#0000000000000100;	// SP CORRIENTE L3
	D_9406 : real := +0.0;
	D_9407 : word := 2#0000000000000000;
	D_9408 : int  := +00000;
	D_9409 : int  := +00000;
	D_9410 : int  := +00000;
	D_9411 : word := B#(  0, 0);
	D_9412 : word := B#(000,000);
	D_9413 : word := 2#0000000000000000;
	D_9414 : int  := +00000;
	D_9415 : int  := +00000;
	D_9416 : word := B#(  1,  1);	// State (1)
	D_9417 : word := B#(  0,  0);	//
	D_9418 : word := B#(  0,  0);	//
	D_9419 : int  := +00000;	//
	D_9420 : word := 2#0000000000000000;	//
	D_9421 : word := B#(  0,  0);	//
	D_9422 : word := B#(  1,  1);	// State (16)
	D_9423 : word := B#(  0,  1);	//
	D_9424 : word := B#(  15,  12);	//
	D_9425 : int  := +00000;	//
	D_9426 : word := 2#0000000000000000;	//
	D_9427 : word := B#(  0,  0);	//
	D_9428 : real := 0.000000000000;	//
	D_9429 : real := 500.000000000000;	//
	D_9430 : real := 5.000000000000;	//
	D_9431 : real := 5.000000000000;	//
	D_9432 : real := +0.0;	//
	D_9433 : int  := 00000;	//
	D_9434 : int  := 00000;	//
	D_9435 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_9436 : int  := 00000;	//
	D_9437 : int  := +00000;	//
	D_9438 : word  := B#(000,000);	//
	D_9439 : int  := +00000;	//
	D_9440 : word := B#(  2,  5);	//  050407 ( 02662 )
	D_9441 : word := 2#0000000000000100;	// SP POTENCIA KW
	D_9442 : real := +0.0;
	D_9443 : word := 2#0000000000000000;
	D_9444 : int  := +00000;
	D_9445 : int  := +00000;
	D_9446 : int  := +00000;
	D_9447 : word := B#(  0, 0);
	D_9448 : word := B#(000,000);
	D_9449 : word := 2#0000000000000000;
	D_9450 : int  := +00000;
	D_9451 : int  := +00000;
	D_9452 : word := B#(  3,  3);	// State (1)
	D_9453 : word := B#(  0,  1);	//
	D_9454 : word := B#(  14,  0);	//
	D_9455 : int  := +00000;	//
	D_9456 : word := 2#0000000000000000;	//
	D_9457 : word := B#(  0,  0);	//
	D_9458 : word := B#(  3,  3);	// State (2)
	D_9459 : word := B#(  0,  1);	//
	D_9460 : word := B#(  13,  0);	//
	D_9461 : int  := +00000;	//
	D_9462 : word := 2#0000000000000000;	//
	D_9463 : word := B#(  0,  0);	//
	D_9464 : word := B#(  3,  3);	// State (3)
	D_9465 : word := B#(  0,  1);	//
	D_9466 : word := B#(  12,  0);	//
	D_9467 : int  := +00000;	//
	D_9468 : word := 2#0000000000000000;	//
	D_9469 : word := B#(  0,  0);	//
	D_9470 : word := B#(  3,  3);	// State (4)
	D_9471 : word := B#(  0,  0);	//
	D_9472 : word := B#(  0,  0);	//
	D_9473 : int  := +00000;	//
	D_9474 : word := 2#0000000000000000;	//
	D_9475 : word := B#(  0,  0);	//
	D_9476 : word := B#(  3,  3);	// State (5)
	D_9477 : word := B#(  0,  1);	//
	D_9478 : word := B#(  8,  1);	//
	D_9479 : int  := +00000;	//
	D_9480 : word := 2#0000000000000000;	//
	D_9481 : word := B#(  0,  0);	//
	D_9482 : word := B#(  3,  3);	// State (16)
	D_9483 : word := B#(  0,  1);	//
	D_9484 : word := B#(  15,  12);	//
	D_9485 : int  := +00000;	//
	D_9486 : word := 2#0000000000000000;	//
	D_9487 : word := B#(  0,  0);	//
	D_9488 : real := -20.000000000000;	//
	D_9489 : real := 200.000000000000;	//
	D_9490 : real := 2.200000000000;	//
	D_9491 : real := 2.200000000000;	//
	D_9492 : real := +0.0;	//
	D_9493 : int  := 00000;	//
	D_9494 : int  := 00000;	//
	D_9495 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_9496 : int  := 00000;	//
	D_9497 : int  := +00000;	//
	D_9498 : word  := B#(000,000);	//
	D_9499 : int  := +00000;	//
	D_9500 : real := 190.000000000000;	// Limit (1)
	D_9501 : real := +0.0;	//
	D_9502 : int  := +00000;	//
	D_9503 : word := 2#0000000000000000;	//
	D_9504 : int := +00000;	//
	D_9505 : real := 180.000000000000;	// Limit (2)
	D_9506 : real := +0.0;	//
	D_9507 : int  := +00000;	//
	D_9508 : word := 2#0000000000000000;	//
	D_9509 : int := +00000;	//
	D_9510 : real := 150.000000000000;	// Limit (3)
	D_9511 : real := +0.0;	//
	D_9512 : int  := +00000;	//
	D_9513 : word := 2#0000000000000000;	//
	D_9514 : int := +00000;	//
	D_9515 : real := -18.000000000000;	// Limit (4)
	D_9516 : real := +0.0;	//
	D_9517 : int  := +00000;	//
	D_9518 : word := 2#0000000000000000;	//
	D_9519 : int := +00000;	//
	D_9520 : word := B#(  2,  1);	//  050408 ( 02663 )
	D_9521 : word := 2#0000000000000100;	// SP FACTOR DE POTENCIA
	D_9522 : real := +0.0;
	D_9523 : word := 2#0000000000000000;
	D_9524 : int  := +00000;
	D_9525 : int  := +00000;
	D_9526 : int  := +00000;
	D_9527 : word := B#(  0, 0);
	D_9528 : word := B#(000,000);
	D_9529 : word := 2#0000000000000000;
	D_9530 : int  := +00000;
	D_9531 : int  := +00000;
	D_9532 : word := B#(  1,  1);	// State (1)
	D_9533 : word := B#(  0,  0);	//
	D_9534 : word := B#(  0,  0);	//
	D_9535 : int  := +00000;	//
	D_9536 : word := 2#0000000000000000;	//
	D_9537 : word := B#(  0,  0);	//
	D_9538 : word := B#(  1,  1);	// State (16)
	D_9539 : word := B#(  0,  1);	//
	D_9540 : word := B#(  15,  12);	//
	D_9541 : int  := +00000;	//
	D_9542 : word := 2#0000000000000000;	//
	D_9543 : word := B#(  0,  0);	//
	D_9544 : real := -1.000000000000;	//
	D_9545 : real := 1.000000000000;	//
	D_9546 : real := 0.020000000000;	//
	D_9547 : real := 0.020000000000;	//
	D_9548 : real := +0.0;	//
	D_9549 : int  := 00000;	//
	D_9550 : int  := 00000;	//
	D_9551 : word  := B#(002,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_9552 : int  := 00000;	//
	D_9553 : int  := +00000;	//
	D_9554 : word  := B#(000,000);	//
	D_9555 : int  := +00000;	//
	D_9556 : word := B#(  2,  1);	//  050409 ( 02664 )
	D_9557 : word := 2#0000000000000100;	// SP POTENCIA REACTIVE KVAR
	D_9558 : real := +0.0;
	D_9559 : word := 2#0000000000000000;
	D_9560 : int  := +00000;
	D_9561 : int  := +00000;
	D_9562 : int  := +00000;
	D_9563 : word := B#(  0, 0);
	D_9564 : word := B#(000,000);
	D_9565 : word := 2#0000000000000000;
	D_9566 : int  := +00000;
	D_9567 : int  := +00000;
	D_9568 : word := B#(  1,  1);	// State (1)
	D_9569 : word := B#(  0,  0);	//
	D_9570 : word := B#(  0,  0);	//
	D_9571 : int  := +00000;	//
	D_9572 : word := 2#0000000000000000;	//
	D_9573 : word := B#(  0,  0);	//
	D_9574 : word := B#(  1,  1);	// State (16)
	D_9575 : word := B#(  0,  1);	//
	D_9576 : word := B#(  15,  12);	//
	D_9577 : int  := +00000;	//
	D_9578 : word := 2#0000000000000000;	//
	D_9579 : word := B#(  0,  0);	//
	D_9580 : real := 0.000000000000;	//
	D_9581 : real := 150.000000000000;	//
	D_9582 : real := 1.500000000000;	//
	D_9583 : real := 1.500000000000;	//
	D_9584 : real := +0.0;	//
	D_9585 : int  := 00000;	//
	D_9586 : int  := 00000;	//
	D_9587 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_9588 : int  := 00000;	//
	D_9589 : int  := +00000;	//
	D_9590 : word  := B#(000,000);	//
	D_9591 : int  := +00000;	//
	D_9592 : word := B#(  2,  5);	//  050415 ( 02665 )
	D_9593 : word := 2#0000000000000100;	// SP FRECUENCIA
	D_9594 : real := +0.0;
	D_9595 : word := 2#0000000000000000;
	D_9596 : int  := +00028;
	D_9597 : int  := +00000;
	D_9598 : int  := +00000;
	D_9599 : word := B#(  0, 0);
	D_9600 : word := B#(000,000);
	D_9601 : word := 2#0000000000000000;
	D_9602 : int  := +00000;
	D_9603 : int  := +00000;
	D_9604 : word := B#(  5,  5);	// State (1)
	D_9605 : word := B#(  0,  1);	//
	D_9606 : word := B#(  13,  0);	//
	D_9607 : int  := +00000;	//
	D_9608 : word := 2#0000000000000000;	//
	D_9609 : word := B#(  0,  0);	//
	D_9610 : word := B#(  5,  5);	// State (2)
	D_9611 : word := B#(  0,  0);	//
	D_9612 : word := B#(  0,  0);	//
	D_9613 : int  := +00000;	//
	D_9614 : word := 2#0000000000000000;	//
	D_9615 : word := B#(  0,  0);	//
	D_9616 : word := B#(  5,  5);	// State (3)
	D_9617 : word := B#(  0,  1);	//
	D_9618 : word := B#(  6,  1);	//
	D_9619 : int  := +00205;	//
	D_9620 : word := 2#0000000000000000;	//
	D_9621 : word := B#(  0,  0);	//
	D_9622 : word := B#(  5,  5);	// State (4)
	D_9623 : word := B#(  0,  1);	//
	D_9624 : word := B#(  7,  1);	//
	D_9625 : int  := +00205;	//
	D_9626 : word := 2#0000000000000000;	//
	D_9627 : word := B#(  0,  0);	//
	D_9628 : word := B#(  5,  5);	// State (5)
	D_9629 : word := B#(  0,  1);	//
	D_9630 : word := B#(  8,  1);	//
	D_9631 : int  := +00205;	//
	D_9632 : word := 2#0000000000000000;	//
	D_9633 : word := B#(  0,  0);	//
	D_9634 : word := B#(  5,  5);	// State (16)
	D_9635 : word := B#(  0,  1);	//
	D_9636 : word := B#(  15,  12);	//
	D_9637 : int  := +00205;	//
	D_9638 : word := 2#0000000000000000;	//
	D_9639 : word := B#(  0,  0);	//
	D_9640 : real := 0.000000000000;	//
	D_9641 : real := 65.000000000000;	//
	D_9642 : real := 0.325000000000;	//
	D_9643 : real := 0.650000000000;	//
	D_9644 : real := +0.0;	//
	D_9645 : int  := 00000;	//
	D_9646 : int  := 00000;	//
	D_9647 : word  := B#(001,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_9648 : int  := 00000;	//
	D_9649 : int  := +00000;	//
	D_9650 : word  := B#(000,000);	//
	D_9651 : int  := +00000;	//
	D_9652 : real := 62.500000000000;	// Limit (1)
	D_9653 : real := +0.0;	//
	D_9654 : int  := +00000;	//
	D_9655 : word := 2#0000000000000000;	//
	D_9656 : int := +00000;	//
	D_9657 : real := 57.500000000000;	// Limit (2)
	D_9658 : real := +0.0;	//
	D_9659 : int  := +00000;	//
	D_9660 : word := 2#0000000000000000;	//
	D_9661 : int := +00000;	//
	D_9662 : real := 56.000000000000;	// Limit (3)
	D_9663 : real := +0.0;	//
	D_9664 : int  := +00000;	//
	D_9665 : word := 2#0000000000000000;	//
	D_9666 : int := +00000;	//
	D_9667 : real := 55.000000000000;	// Limit (4)
	D_9668 : real := +0.0;	//
	D_9669 : int  := +00000;	//
	D_9670 : word := 2#0000000000000000;	//
	D_9671 : int := +00000;	//
	D_9672 : word := B#(  2,  3);	//  050501 ( 02666 )
	D_9673 : word := 2#0000000000000100;	// VOLTAGE BANCO DE BATERIAS No 1
	D_9674 : real := +0.0;
	D_9675 : word := 2#0000000000000000;
	D_9676 : int  := +00000;
	D_9677 : int  := +00000;
	D_9678 : int  := +00000;
	D_9679 : word := B#(  0, 0);
	D_9680 : word := B#(000,000);
	D_9681 : word := 2#0000000000000000;
	D_9682 : int  := +00000;
	D_9683 : int  := +00000;
	D_9684 : word := B#(  5,  5);	// State (1)
	D_9685 : word := B#(  0,  1);	//
	D_9686 : word := B#(  5,  8);	//
	D_9687 : int  := +00000;	//
	D_9688 : word := 2#0000000000000000;	//
	D_9689 : word := B#(  0,  0);	//
	D_9690 : word := B#(  5,  5);	// State (2)
	D_9691 : word := B#(  0,  0);	//
	D_9692 : word := B#(  0,  0);	//
	D_9693 : int  := +00000;	//
	D_9694 : word := 2#0000000000000000;	//
	D_9695 : word := B#(  0,  0);	//
	D_9696 : word := B#(  5,  5);	// State (3)
	D_9697 : word := B#(  0,  1);	//
	D_9698 : word := B#(  3,  5);	//
	D_9699 : int  := +00000;	//
	D_9700 : word := 2#0000000000000000;	//
	D_9701 : word := B#(  0,  0);	//
	D_9702 : word := B#(  5,  5);	// State (16)
	D_9703 : word := B#(  0,  1);	//
	D_9704 : word := B#(  15,  12);	//
	D_9705 : int  := +00000;	//
	D_9706 : word := 2#0000000000000000;	//
	D_9707 : word := B#(  0,  0);	//
	D_9708 : real := 0.002314814815;	//
	D_9709 : real := 0.000000000000;	//
	D_9710 : real := 0.000000000000;	//
	D_9711 : real := 0.320000000000;	//
	D_9712 : real := +0.0;	//
	D_9713 : int  := -1382;	//
	D_9714 : int  := 29030;	//
	D_9715 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_9716 : int  := 00000;	//
	D_9717 : int  := +00000;	//
	D_9718 : word  := B#(000,000);	//
	D_9719 : int  := +00000;	//
	D_9720 : real := 26.000000000000;	// Limit (1)
	D_9721 : real := +0.0;	//
	D_9722 : int  := +00000;	//
	D_9723 : word := 2#0000000000000000;	//
	D_9724 : int := +00000;	//
	D_9725 : real := 22.000000000000;	// Limit (2)
	D_9726 : real := +0.0;	//
	D_9727 : int  := +00000;	//
	D_9728 : word := 2#0000000000000000;	//
	D_9729 : int := +00000;	//
	D_9730 : word := B#(  2,  3);	//  050502 ( 02667 )
	D_9731 : word := 2#0000000000000100;	// VOLTAGE BANCO DE BATERIAS No 2
	D_9732 : real := +0.0;
	D_9733 : word := 2#0000000000000000;
	D_9734 : int  := +00000;
	D_9735 : int  := +00000;
	D_9736 : int  := +00000;
	D_9737 : word := B#(  0, 0);
	D_9738 : word := B#(000,000);
	D_9739 : word := 2#0000000000000000;
	D_9740 : int  := +00000;
	D_9741 : int  := +00000;
	D_9742 : word := B#(  5,  5);	// State (1)
	D_9743 : word := B#(  0,  1);	//
	D_9744 : word := B#(  5,  8);	//
	D_9745 : int  := +00000;	//
	D_9746 : word := 2#0000000000000000;	//
	D_9747 : word := B#(  0,  0);	//
	D_9748 : word := B#(  5,  5);	// State (2)
	D_9749 : word := B#(  0,  0);	//
	D_9750 : word := B#(  0,  0);	//
	D_9751 : int  := +00000;	//
	D_9752 : word := 2#0000000000000000;	//
	D_9753 : word := B#(  0,  0);	//
	D_9754 : word := B#(  5,  5);	// State (3)
	D_9755 : word := B#(  0,  1);	//
	D_9756 : word := B#(  3,  5);	//
	D_9757 : int  := +00000;	//
	D_9758 : word := 2#0000000000000000;	//
	D_9759 : word := B#(  0,  0);	//
	D_9760 : word := B#(  5,  5);	// State (16)
	D_9761 : word := B#(  0,  1);	//
	D_9762 : word := B#(  15,  12);	//
	D_9763 : int  := +00000;	//
	D_9764 : word := 2#0000000000000000;	//
	D_9765 : word := B#(  0,  0);	//
	D_9766 : real := 0.002314814815;	//
	D_9767 : real := 0.000000000000;	//
	D_9768 : real := 0.000000000000;	//
	D_9769 : real := 0.320000000000;	//
	D_9770 : real := +0.0;	//
	D_9771 : int  := -1382;	//
	D_9772 : int  := 29030;	//
	D_9773 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_9774 : int  := 00000;	//
	D_9775 : int  := +00000;	//
	D_9776 : word  := B#(000,000);	//
	D_9777 : int  := +00000;	//
	D_9778 : real := 26.000000000000;	// Limit (1)
	D_9779 : real := +0.0;	//
	D_9780 : int  := +00000;	//
	D_9781 : word := 2#0000000000000000;	//
	D_9782 : int := +00000;	//
	D_9783 : real := 22.000000000000;	// Limit (2)
	D_9784 : real := +0.0;	//
	D_9785 : int  := +00000;	//
	D_9786 : word := 2#0000000000000000;	//
	D_9787 : int := +00000;	//
	D_9788 : word := B#(  2,  1);	//  050503 ( 02668 )
	D_9789 : word := 2#0000000000000100;	// CORRIENTE BANCO DE BATERIAS 1
	D_9790 : real := +0.0;
	D_9791 : word := 2#0000000000000000;
	D_9792 : int  := +00000;
	D_9793 : int  := +00000;
	D_9794 : int  := +00000;
	D_9795 : word := B#(  0, 0);
	D_9796 : word := B#(000,000);
	D_9797 : word := 2#0000000000000000;
	D_9798 : int  := +00000;
	D_9799 : int  := +00000;
	D_9800 : word := B#(  1,  1);	// State (1)
	D_9801 : word := B#(  0,  0);	//
	D_9802 : word := B#(  0,  0);	//
	D_9803 : int  := +00000;	//
	D_9804 : word := 2#0000000000000000;	//
	D_9805 : word := B#(  0,  0);	//
	D_9806 : word := B#(  1,  1);	// State (16)
	D_9807 : word := B#(  0,  1);	//
	D_9808 : word := B#(  15,  12);	//
	D_9809 : int  := +00000;	//
	D_9810 : word := 2#0000000000000000;	//
	D_9811 : word := B#(  0,  0);	//
	D_9812 : real := 0.017939814815;	//
	D_9813 : real := 0.000000000000;	//
	D_9814 : real := 4.960000000000;	//
	D_9815 : real := 4.960000000000;	//
	D_9816 : real := +0.0;	//
	D_9817 : int  := -1382;	//
	D_9818 : int  := 29030;	//
	D_9819 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_9820 : int  := 00000;	//
	D_9821 : int  := +00000;	//
	D_9822 : word  := B#(000,000);	//
	D_9823 : int  := +00000;	//
	D_9824 : word := B#(  2,  1);	//  050504 ( 02669 )
	D_9825 : word := 2#0000000000000100;	// CORRIENTE BANCO DE BATERIAS 2
	D_9826 : real := +0.0;
	D_9827 : word := 2#0000000000000000;
	D_9828 : int  := +00000;
	D_9829 : int  := +00000;
	D_9830 : int  := +00000;
	D_9831 : word := B#(  0, 0);
	D_9832 : word := B#(000,000);
	D_9833 : word := 2#0000000000000000;
	D_9834 : int  := +00000;
	D_9835 : int  := +00000;
	D_9836 : word := B#(  1,  1);	// State (1)
	D_9837 : word := B#(  0,  0);	//
	D_9838 : word := B#(  0,  0);	//
	D_9839 : int  := +00000;	//
	D_9840 : word := 2#0000000000000000;	//
	D_9841 : word := B#(  0,  0);	//
	D_9842 : word := B#(  1,  1);	// State (16)
	D_9843 : word := B#(  0,  1);	//
	D_9844 : word := B#(  15,  12);	//
	D_9845 : int  := +00000;	//
	D_9846 : word := 2#0000000000000000;	//
	D_9847 : word := B#(  0,  0);	//
	D_9848 : real := 0.017939814815;	//
	D_9849 : real := 0.000000000000;	//
	D_9850 : real := 4.960000000000;	//
	D_9851 : real := 4.960000000000;	//
	D_9852 : real := +0.0;	//
	D_9853 : int  := -1382;	//
	D_9854 : int  := 29030;	//
	D_9855 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_9856 : int  := 00000;	//
	D_9857 : int  := +00000;	//
	D_9858 : word  := B#(000,000);	//
	D_9859 : int  := +00000;	//
	D_9860 : word := B#(  2,  5);	//  060101 ( 02670 )
	D_9861 : word := 2#0000000000000100;	// NIVEL TANQUE DE COMBUSTIBLE 1
	D_9862 : real := +0.0;
	D_9863 : word := 2#0000000000000000;
	D_9864 : int  := +00000;
	D_9865 : int  := +00000;
	D_9866 : int  := +00000;
	D_9867 : word := B#(  0, 0);
	D_9868 : word := B#(000,000);
	D_9869 : word := 2#0000000000000000;
	D_9870 : int  := +00000;
	D_9871 : int  := +00000;
	D_9872 : word := B#(  15,  15);	// State (1)
	D_9873 : word := B#(  0,  1);	//
	D_9874 : word := B#(  13,  0);	//
	D_9875 : int  := +00000;	//
	D_9876 : word := 2#0000000000000000;	//
	D_9877 : word := B#(  0,  0);	//
	D_9878 : word := B#(  15,  15);	// State (2)
	D_9879 : word := B#(  0,  1);	//
	D_9880 : word := B#(  12,  0);	//
	D_9881 : int  := +00000;	//
	D_9882 : word := 2#0000000000000000;	//
	D_9883 : word := B#(  0,  0);	//
	D_9884 : word := B#(  15,  15);	// State (3)
	D_9885 : word := B#(  0,  0);	//
	D_9886 : word := B#(  0,  0);	//
	D_9887 : int  := +00000;	//
	D_9888 : word := 2#0000000000000000;	//
	D_9889 : word := B#(  0,  0);	//
	D_9890 : word := B#(  15,  15);	// State (4)
	D_9891 : word := B#(  0,  1);	//
	D_9892 : word := B#(  3,  5);	//
	D_9893 : int  := +00000;	//
	D_9894 : word := 2#0000000000000000;	//
	D_9895 : word := B#(  0,  0);	//
	D_9896 : word := B#(  15,  15);	// State (5)
	D_9897 : word := B#(  0,  1);	//
	D_9898 : word := B#(  5,  9);	//
	D_9899 : int  := +00000;	//
	D_9900 : word := 2#0000000000000000;	//
	D_9901 : word := B#(  0,  0);	//
	D_9902 : word := B#(  15,  15);	// State (16)
	D_9903 : word := B#(  0,  1);	//
	D_9904 : word := B#(  15,  12);	//
	D_9905 : int  := +00000;	//
	D_9906 : word := 2#0000000000000000;	//
	D_9907 : word := B#(  0,  0);	//
	D_9908 : real := 0.007957175926;	//
	D_9909 : real := 2.000000000000;	//
	D_9910 : real := 0.000000000000;	//
	D_9911 : real := 1.100000000000;	//
	D_9912 : real := +0.0;	//
	D_9913 : int  := -1382;	//
	D_9914 : int  := 29030;	//
	D_9915 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_9916 : int  := 00000;	//
	D_9917 : int  := +00000;	//
	D_9918 : word  := B#(000,000);	//
	D_9919 : int  := +00000;	//
	D_9920 : real := 208.680000000000;	// Limit (1)
	D_9921 : real := +0.0;	//
	D_9922 : int  := +00000;	//
	D_9923 : word := 2#0000000000000000;	//
	D_9924 : int := +00000;	//
	D_9925 : real := 199.800000000000;	// Limit (2)
	D_9926 : real := +0.0;	//
	D_9927 : int  := +00000;	//
	D_9928 : word := 2#0000000000000000;	//
	D_9929 : int := +00000;	//
	D_9930 : real := 33.300000000000;	// Limit (3)
	D_9931 : real := +0.0;	//
	D_9932 : int  := +00000;	//
	D_9933 : word := 2#0000000000000000;	//
	D_9934 : int := +00000;	//
	D_9935 : real := 22.200000000000;	// Limit (4)
	D_9936 : real := +0.0;	//
	D_9937 : int  := +00000;	//
	D_9938 : word := 2#0000000000000000;	//
	D_9939 : int := +00000;	//
	D_9940 : word := B#(  2,  5);	//  060102 ( 02671 )
	D_9941 : word := 2#0000000000000100;	// NIVEL TANQUE DE COMBUSTIBLE 2
	D_9942 : real := +0.0;
	D_9943 : word := 2#0000000000000000;
	D_9944 : int  := +00000;
	D_9945 : int  := +00000;
	D_9946 : int  := +00000;
	D_9947 : word := B#(  0, 0);
	D_9948 : word := B#(000,000);
	D_9949 : word := 2#0000000000000000;
	D_9950 : int  := +00000;
	D_9951 : int  := +00000;
	D_9952 : word := B#(  15,  15);	// State (1)
	D_9953 : word := B#(  0,  1);	//
	D_9954 : word := B#(  13,  0);	//
	D_9955 : int  := +00000;	//
	D_9956 : word := 2#0000000000000000;	//
	D_9957 : word := B#(  0,  0);	//
	D_9958 : word := B#(  15,  15);	// State (2)
	D_9959 : word := B#(  0,  1);	//
	D_9960 : word := B#(  12,  0);	//
	D_9961 : int  := +00000;	//
	D_9962 : word := 2#0000000000000000;	//
	D_9963 : word := B#(  0,  0);	//
	D_9964 : word := B#(  15,  15);	// State (3)
	D_9965 : word := B#(  0,  0);	//
	D_9966 : word := B#(  0,  0);	//
	D_9967 : int  := +00000;	//
	D_9968 : word := 2#0000000000000000;	//
	D_9969 : word := B#(  0,  0);	//
	D_9970 : word := B#(  15,  15);	// State (4)
	D_9971 : word := B#(  0,  1);	//
	D_9972 : word := B#(  3,  5);	//
	D_9973 : int  := +00000;	//
	D_9974 : word := 2#0000000000000000;	//
	D_9975 : word := B#(  0,  0);	//
	D_9976 : word := B#(  15,  15);	// State (5)
	D_9977 : word := B#(  0,  1);	//
	D_9978 : word := B#(  5,  9);	//
	D_9979 : int  := +00000;	//
	D_9980 : word := 2#0000000000000000;	//
	D_9981 : word := B#(  0,  0);	//
	D_9982 : word := B#(  15,  15);	// State (16)
	D_9983 : word := B#(  0,  1);	//
	D_9984 : word := B#(  15,  12);	//
	D_9985 : int  := +00000;	//
	D_9986 : word := 2#0000000000000000;	//
	D_9987 : word := B#(  0,  0);	//
	D_9988 : real := 0.007523148148;	//
	D_9989 : real := 2.000000000000;	//
	D_9990 : real := 1.040000000000;	//
	D_9991 : real := 1.040000000000;	//
	D_9992 : real := +0.0;	//
	D_9993 : int  := -1382;	//
	D_9994 : int  := 29030;	//
	D_9995 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_9996 : int  := 00000;	//
	D_9997 : int  := +00000;	//
	D_9998 : word  := B#(000,000);	//
	D_9999 : int  := +00000;	//
	D_10000 : real := 197.400000000000;	// Limit (1)
	D_10001 : real := +0.0;	//
	D_10002 : int  := +00000;	//
	D_10003 : word := 2#0000000000000000;	//
	D_10004 : int := +00000;	//
	D_10005 : real := 189.000000000000;	// Limit (2)
	D_10006 : real := +0.0;	//
	D_10007 : int  := +00000;	//
	D_10008 : word := 2#0000000000000000;	//
	D_10009 : int := +00000;	//
	D_10010 : real := 31.500000000000;	// Limit (3)
	D_10011 : real := +0.0;	//
	D_10012 : int  := +00000;	//
	D_10013 : word := 2#0000000000000000;	//
	D_10014 : int := +00000;	//
	D_10015 : real := 21.000000000000;	// Limit (4)
	D_10016 : real := +0.0;	//
	D_10017 : int  := +00000;	//
	D_10018 : word := 2#0000000000000000;	//
	D_10019 : int := +00000;	//
	D_10020 : word := B#(  2,  5);	//  060103 ( 02672 )
	D_10021 : word := 2#0000000000000100;	// NIVEL TANQUE DE COMBUSTIBLE 3
	D_10022 : real := +0.0;
	D_10023 : word := 2#0000000000000000;
	D_10024 : int  := +00000;
	D_10025 : int  := +00000;
	D_10026 : int  := +00000;
	D_10027 : word := B#(  0, 0);
	D_10028 : word := B#(000,000);
	D_10029 : word := 2#0000000000000000;
	D_10030 : int  := +00000;
	D_10031 : int  := +00000;
	D_10032 : word := B#(  15,  15);	// State (1)
	D_10033 : word := B#(  0,  1);	//
	D_10034 : word := B#(  13,  0);	//
	D_10035 : int  := +00000;	//
	D_10036 : word := 2#0000000000000000;	//
	D_10037 : word := B#(  0,  0);	//
	D_10038 : word := B#(  15,  15);	// State (2)
	D_10039 : word := B#(  0,  1);	//
	D_10040 : word := B#(  12,  0);	//
	D_10041 : int  := +00000;	//
	D_10042 : word := 2#0000000000000000;	//
	D_10043 : word := B#(  0,  0);	//
	D_10044 : word := B#(  15,  15);	// State (3)
	D_10045 : word := B#(  0,  0);	//
	D_10046 : word := B#(  0,  0);	//
	D_10047 : int  := +00000;	//
	D_10048 : word := 2#0000000000000000;	//
	D_10049 : word := B#(  0,  0);	//
	D_10050 : word := B#(  15,  15);	// State (4)
	D_10051 : word := B#(  0,  1);	//
	D_10052 : word := B#(  3,  5);	//
	D_10053 : int  := +00000;	//
	D_10054 : word := 2#0000000000000000;	//
	D_10055 : word := B#(  0,  0);	//
	D_10056 : word := B#(  15,  15);	// State (5)
	D_10057 : word := B#(  0,  1);	//
	D_10058 : word := B#(  5,  9);	//
	D_10059 : int  := +00000;	//
	D_10060 : word := 2#0000000000000000;	//
	D_10061 : word := B#(  0,  0);	//
	D_10062 : word := B#(  15,  15);	// State (16)
	D_10063 : word := B#(  0,  1);	//
	D_10064 : word := B#(  15,  12);	//
	D_10065 : int  := +00000;	//
	D_10066 : word := 2#0000000000000000;	//
	D_10067 : word := B#(  0,  0);	//
	D_10068 : real := 0.007523148148;	//
	D_10069 : real := 2.000000000000;	//
	D_10070 : real := 0.000000000000;	//
	D_10071 : real := 1.040000000000;	//
	D_10072 : real := +0.0;	//
	D_10073 : int  := -1382;	//
	D_10074 : int  := 29030;	//
	D_10075 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_10076 : int  := 00000;	//
	D_10077 : int  := +00000;	//
	D_10078 : word  := B#(000,000);	//
	D_10079 : int  := +00000;	//
	D_10080 : real := 197.400000000000;	// Limit (1)
	D_10081 : real := +0.0;	//
	D_10082 : int  := +00000;	//
	D_10083 : word := 2#0000000000000000;	//
	D_10084 : int := +00000;	//
	D_10085 : real := 189.000000000000;	// Limit (2)
	D_10086 : real := +0.0;	//
	D_10087 : int  := +00000;	//
	D_10088 : word := 2#0000000000000000;	//
	D_10089 : int := +00000;	//
	D_10090 : real := 31.500000000000;	// Limit (3)
	D_10091 : real := +0.0;	//
	D_10092 : int  := +00000;	//
	D_10093 : word := 2#0000000000000000;	//
	D_10094 : int := +00000;	//
	D_10095 : real := 21.000000000000;	// Limit (4)
	D_10096 : real := +0.0;	//
	D_10097 : int  := +00000;	//
	D_10098 : word := 2#0000000000000000;	//
	D_10099 : int := +00000;	//
	D_10100 : word := B#(  2,  5);	//  060104 ( 02673 )
	D_10101 : word := 2#0000000000000100;	// NIVEL TANQUE DE COMBUSTIBLE 4
	D_10102 : real := +0.0;
	D_10103 : word := 2#0000000000000000;
	D_10104 : int  := +00000;
	D_10105 : int  := +00000;
	D_10106 : int  := +00000;
	D_10107 : word := B#(  0, 0);
	D_10108 : word := B#(000,000);
	D_10109 : word := 2#0000000000000000;
	D_10110 : int  := +00000;
	D_10111 : int  := +00000;
	D_10112 : word := B#(  15,  15);	// State (1)
	D_10113 : word := B#(  0,  1);	//
	D_10114 : word := B#(  13,  0);	//
	D_10115 : int  := +00000;	//
	D_10116 : word := 2#0000000000000000;	//
	D_10117 : word := B#(  0,  0);	//
	D_10118 : word := B#(  15,  15);	// State (2)
	D_10119 : word := B#(  0,  1);	//
	D_10120 : word := B#(  12,  0);	//
	D_10121 : int  := +00000;	//
	D_10122 : word := 2#0000000000000000;	//
	D_10123 : word := B#(  0,  0);	//
	D_10124 : word := B#(  15,  15);	// State (3)
	D_10125 : word := B#(  0,  0);	//
	D_10126 : word := B#(  0,  0);	//
	D_10127 : int  := +00000;	//
	D_10128 : word := 2#0000000000000000;	//
	D_10129 : word := B#(  0,  0);	//
	D_10130 : word := B#(  15,  15);	// State (4)
	D_10131 : word := B#(  0,  1);	//
	D_10132 : word := B#(  3,  5);	//
	D_10133 : int  := +00000;	//
	D_10134 : word := 2#0000000000000000;	//
	D_10135 : word := B#(  0,  0);	//
	D_10136 : word := B#(  15,  15);	// State (5)
	D_10137 : word := B#(  0,  1);	//
	D_10138 : word := B#(  5,  9);	//
	D_10139 : int  := +00000;	//
	D_10140 : word := 2#0000000000000000;	//
	D_10141 : word := B#(  0,  0);	//
	D_10142 : word := B#(  15,  15);	// State (16)
	D_10143 : word := B#(  0,  1);	//
	D_10144 : word := B#(  15,  12);	//
	D_10145 : int  := +00000;	//
	D_10146 : word := 2#0000000000000000;	//
	D_10147 : word := B#(  0,  0);	//
	D_10148 : real := 0.011501736111;	//
	D_10149 : real := 2.000000000000;	//
	D_10150 : real := 0.000000000000;	//
	D_10151 : real := 1.590000000000;	//
	D_10152 : real := +0.0;	//
	D_10153 : int  := -1382;	//
	D_10154 : int  := 29030;	//
	D_10155 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_10156 : int  := 00000;	//
	D_10157 : int  := +00000;	//
	D_10158 : word  := B#(000,000);	//
	D_10159 : int  := +00000;	//
	D_10160 : real := 300.800000000000;	// Limit (1)
	D_10161 : real := +0.0;	//
	D_10162 : int  := +00000;	//
	D_10163 : word := 2#0000000000000000;	//
	D_10164 : int := +00000;	//
	D_10165 : real := 288.000000000000;	// Limit (2)
	D_10166 : real := +0.0;	//
	D_10167 : int  := +00000;	//
	D_10168 : word := 2#0000000000000000;	//
	D_10169 : int := +00000;	//
	D_10170 : real := 48.000000000000;	// Limit (3)
	D_10171 : real := +0.0;	//
	D_10172 : int  := +00000;	//
	D_10173 : word := 2#0000000000000000;	//
	D_10174 : int := +00000;	//
	D_10175 : real := 32.000000000000;	// Limit (4)
	D_10176 : real := +0.0;	//
	D_10177 : int  := +00000;	//
	D_10178 : word := 2#0000000000000000;	//
	D_10179 : int := +00000;	//
	D_10180 : word := B#(  2,  5);	//  060105 ( 02674 )
	D_10181 : word := 2#0000000000000100;	// NIVEL TANQUE DE COMBUSTIBLE 5
	D_10182 : real := +0.0;
	D_10183 : word := 2#0000000000000000;
	D_10184 : int  := +00000;
	D_10185 : int  := +00000;
	D_10186 : int  := +00000;
	D_10187 : word := B#(  0, 0);
	D_10188 : word := B#(000,000);
	D_10189 : word := 2#0000000000000000;
	D_10190 : int  := +00000;
	D_10191 : int  := +00000;
	D_10192 : word := B#(  15,  15);	// State (1)
	D_10193 : word := B#(  0,  1);	//
	D_10194 : word := B#(  13,  0);	//
	D_10195 : int  := +00000;	//
	D_10196 : word := 2#0000000000000000;	//
	D_10197 : word := B#(  0,  0);	//
	D_10198 : word := B#(  15,  15);	// State (2)
	D_10199 : word := B#(  0,  1);	//
	D_10200 : word := B#(  12,  0);	//
	D_10201 : int  := +00000;	//
	D_10202 : word := 2#0000000000000000;	//
	D_10203 : word := B#(  0,  0);	//
	D_10204 : word := B#(  15,  15);	// State (3)
	D_10205 : word := B#(  0,  0);	//
	D_10206 : word := B#(  0,  0);	//
	D_10207 : int  := +00000;	//
	D_10208 : word := 2#0000000000000000;	//
	D_10209 : word := B#(  0,  0);	//
	D_10210 : word := B#(  15,  15);	// State (4)
	D_10211 : word := B#(  0,  1);	//
	D_10212 : word := B#(  3,  5);	//
	D_10213 : int  := +00000;	//
	D_10214 : word := 2#0000000000000000;	//
	D_10215 : word := B#(  0,  0);	//
	D_10216 : word := B#(  15,  15);	// State (5)
	D_10217 : word := B#(  0,  1);	//
	D_10218 : word := B#(  5,  9);	//
	D_10219 : int  := +00000;	//
	D_10220 : word := 2#0000000000000000;	//
	D_10221 : word := B#(  0,  0);	//
	D_10222 : word := B#(  15,  15);	// State (16)
	D_10223 : word := B#(  0,  1);	//
	D_10224 : word := B#(  15,  12);	//
	D_10225 : int  := +00000;	//
	D_10226 : word := 2#0000000000000000;	//
	D_10227 : word := B#(  0,  0);	//
	D_10228 : real := 0.010054976852;	//
	D_10229 : real := 2.000000000000;	//
	D_10230 : real := 0.000000000000;	//
	D_10231 : real := 1.390000000000;	//
	D_10232 : real := +0.0;	//
	D_10233 : int  := -1382;	//
	D_10234 : int  := 29030;	//
	D_10235 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_10236 : int  := 00000;	//
	D_10237 : int  := +00000;	//
	D_10238 : word  := B#(000,000);	//
	D_10239 : int  := +00000;	//
	D_10240 : real := 263.200000000000;	// Limit (1)
	D_10241 : real := +0.0;	//
	D_10242 : int  := +00000;	//
	D_10243 : word := 2#0000000000000000;	//
	D_10244 : int := +00000;	//
	D_10245 : real := 252.000000000000;	// Limit (2)
	D_10246 : real := +0.0;	//
	D_10247 : int  := +00000;	//
	D_10248 : word := 2#0000000000000000;	//
	D_10249 : int := +00000;	//
	D_10250 : real := 42.000000000000;	// Limit (3)
	D_10251 : real := +0.0;	//
	D_10252 : int  := +00000;	//
	D_10253 : word := 2#0000000000000000;	//
	D_10254 : int := +00000;	//
	D_10255 : real := 28.000000000000;	// Limit (4)
	D_10256 : real := +0.0;	//
	D_10257 : int  := +00000;	//
	D_10258 : word := 2#0000000000000000;	//
	D_10259 : int := +00000;	//
	D_10260 : word := B#(  2,  5);	//  060106 ( 02675 )
	D_10261 : word := 2#0000000000000100;	// NIVEL TANQUE DE COMBUSTIBLE 6
	D_10262 : real := +0.0;
	D_10263 : word := 2#0000000000000000;
	D_10264 : int  := +00000;
	D_10265 : int  := +00000;
	D_10266 : int  := +00000;
	D_10267 : word := B#(  0, 0);
	D_10268 : word := B#(000,000);
	D_10269 : word := 2#0000000000000000;
	D_10270 : int  := +00000;
	D_10271 : int  := +00000;
	D_10272 : word := B#(  15,  15);	// State (1)
	D_10273 : word := B#(  0,  1);	//
	D_10274 : word := B#(  13,  0);	//
	D_10275 : int  := +00000;	//
	D_10276 : word := 2#0000000000000000;	//
	D_10277 : word := B#(  0,  0);	//
	D_10278 : word := B#(  15,  15);	// State (2)
	D_10279 : word := B#(  0,  1);	//
	D_10280 : word := B#(  12,  0);	//
	D_10281 : int  := +00000;	//
	D_10282 : word := 2#0000000000000000;	//
	D_10283 : word := B#(  0,  0);	//
	D_10284 : word := B#(  15,  15);	// State (3)
	D_10285 : word := B#(  0,  0);	//
	D_10286 : word := B#(  0,  0);	//
	D_10287 : int  := +00000;	//
	D_10288 : word := 2#0000000000000000;	//
	D_10289 : word := B#(  0,  0);	//
	D_10290 : word := B#(  15,  15);	// State (4)
	D_10291 : word := B#(  0,  1);	//
	D_10292 : word := B#(  3,  5);	//
	D_10293 : int  := +00000;	//
	D_10294 : word := 2#0000000000000000;	//
	D_10295 : word := B#(  0,  0);	//
	D_10296 : word := B#(  15,  15);	// State (5)
	D_10297 : word := B#(  0,  1);	//
	D_10298 : word := B#(  5,  9);	//
	D_10299 : int  := +00000;	//
	D_10300 : word := 2#0000000000000000;	//
	D_10301 : word := B#(  0,  0);	//
	D_10302 : word := B#(  15,  15);	// State (16)
	D_10303 : word := B#(  0,  1);	//
	D_10304 : word := B#(  15,  12);	//
	D_10305 : int  := +00000;	//
	D_10306 : word := 2#0000000000000000;	//
	D_10307 : word := B#(  0,  0);	//
	D_10308 : real := 0.010054976852;	//
	D_10309 : real := 2.000000000000;	//
	D_10310 : real := 0.000000000000;	//
	D_10311 : real := 1.390000000000;	//
	D_10312 : real := +0.0;	//
	D_10313 : int  := -1382;	//
	D_10314 : int  := 29030;	//
	D_10315 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_10316 : int  := 00000;	//
	D_10317 : int  := +00000;	//
	D_10318 : word  := B#(000,000);	//
	D_10319 : int  := +00000;	//
	D_10320 : real := 263.200000000000;	// Limit (1)
	D_10321 : real := +0.0;	//
	D_10322 : int  := +00000;	//
	D_10323 : word := 2#0000000000000000;	//
	D_10324 : int := +00000;	//
	D_10325 : real := 252.000000000000;	// Limit (2)
	D_10326 : real := +0.0;	//
	D_10327 : int  := +00000;	//
	D_10328 : word := 2#0000000000000000;	//
	D_10329 : int := +00000;	//
	D_10330 : real := 42.000000000000;	// Limit (3)
	D_10331 : real := +0.0;	//
	D_10332 : int  := +00000;	//
	D_10333 : word := 2#0000000000000000;	//
	D_10334 : int := +00000;	//
	D_10335 : real := 28.000000000000;	// Limit (4)
	D_10336 : real := +0.0;	//
	D_10337 : int  := +00000;	//
	D_10338 : word := 2#0000000000000000;	//
	D_10339 : int := +00000;	//
	D_10340 : word := B#(  2,  5);	//  060107 ( 02676 )
	D_10341 : word := 2#0000000000000100;	// NIVEL TANQUE DE COMBUSTIBLE 7
	D_10342 : real := +0.0;
	D_10343 : word := 2#0000000000000000;
	D_10344 : int  := +00000;
	D_10345 : int  := +00000;
	D_10346 : int  := +00000;
	D_10347 : word := B#(  0, 0);
	D_10348 : word := B#(000,000);
	D_10349 : word := 2#0000000000000000;
	D_10350 : int  := +00000;
	D_10351 : int  := +00000;
	D_10352 : word := B#(  15,  15);	// State (1)
	D_10353 : word := B#(  0,  1);	//
	D_10354 : word := B#(  13,  0);	//
	D_10355 : int  := +00000;	//
	D_10356 : word := 2#0000000000000000;	//
	D_10357 : word := B#(  0,  0);	//
	D_10358 : word := B#(  15,  15);	// State (2)
	D_10359 : word := B#(  0,  1);	//
	D_10360 : word := B#(  12,  0);	//
	D_10361 : int  := +00000;	//
	D_10362 : word := 2#0000000000000000;	//
	D_10363 : word := B#(  0,  0);	//
	D_10364 : word := B#(  15,  15);	// State (3)
	D_10365 : word := B#(  0,  0);	//
	D_10366 : word := B#(  0,  0);	//
	D_10367 : int  := +00000;	//
	D_10368 : word := 2#0000000000000000;	//
	D_10369 : word := B#(  0,  0);	//
	D_10370 : word := B#(  15,  15);	// State (4)
	D_10371 : word := B#(  0,  1);	//
	D_10372 : word := B#(  3,  5);	//
	D_10373 : int  := +00000;	//
	D_10374 : word := 2#0000000000000000;	//
	D_10375 : word := B#(  0,  0);	//
	D_10376 : word := B#(  15,  15);	// State (5)
	D_10377 : word := B#(  0,  1);	//
	D_10378 : word := B#(  5,  9);	//
	D_10379 : int  := +00000;	//
	D_10380 : word := 2#0000000000000000;	//
	D_10381 : word := B#(  0,  0);	//
	D_10382 : word := B#(  15,  15);	// State (16)
	D_10383 : word := B#(  0,  1);	//
	D_10384 : word := B#(  15,  12);	//
	D_10385 : int  := +00000;	//
	D_10386 : word := 2#0000000000000000;	//
	D_10387 : word := B#(  0,  0);	//
	D_10388 : real := 0.003544560185;	//
	D_10389 : real := 2.000000000000;	//
	D_10390 : real := 0.000000000000;	//
	D_10391 : real := 0.490000000000;	//
	D_10392 : real := +0.0;	//
	D_10393 : int  := -1382;	//
	D_10394 : int  := 29030;	//
	D_10395 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_10396 : int  := 00000;	//
	D_10397 : int  := +00000;	//
	D_10398 : word  := B#(000,000);	//
	D_10399 : int  := +00000;	//
	D_10400 : real := 94.000000000000;	// Limit (1)
	D_10401 : real := +0.0;	//
	D_10402 : int  := +00000;	//
	D_10403 : word := 2#0000000000000000;	//
	D_10404 : int := +00000;	//
	D_10405 : real := 90.000000000000;	// Limit (2)
	D_10406 : real := +0.0;	//
	D_10407 : int  := +00000;	//
	D_10408 : word := 2#0000000000000000;	//
	D_10409 : int := +00000;	//
	D_10410 : real := 15.000000000000;	// Limit (3)
	D_10411 : real := +0.0;	//
	D_10412 : int  := +00000;	//
	D_10413 : word := 2#0000000000000000;	//
	D_10414 : int := +00000;	//
	D_10415 : real := 10.000000000000;	// Limit (4)
	D_10416 : real := +0.0;	//
	D_10417 : int  := +00000;	//
	D_10418 : word := 2#0000000000000000;	//
	D_10419 : int := +00000;	//
	D_10420 : word := B#(  2,  5);	//  060109 ( 02677 )
	D_10421 : word := 2#0000000000000100;	// NIVEL TANQUE DE COMBUSTIBLE 11
	D_10422 : real := +0.0;
	D_10423 : word := 2#0000000000000000;
	D_10424 : int  := +00000;
	D_10425 : int  := +00000;
	D_10426 : int  := +00000;
	D_10427 : word := B#(  0, 0);
	D_10428 : word := B#(000,000);
	D_10429 : word := 2#0000000000000000;
	D_10430 : int  := +00000;
	D_10431 : int  := +00000;
	D_10432 : word := B#(  15,  15);	// State (1)
	D_10433 : word := B#(  0,  1);	//
	D_10434 : word := B#(  13,  0);	//
	D_10435 : int  := +00000;	//
	D_10436 : word := 2#0000000000000000;	//
	D_10437 : word := B#(  0,  0);	//
	D_10438 : word := B#(  15,  15);	// State (2)
	D_10439 : word := B#(  0,  1);	//
	D_10440 : word := B#(  12,  0);	//
	D_10441 : int  := +00000;	//
	D_10442 : word := 2#0000000000000000;	//
	D_10443 : word := B#(  0,  0);	//
	D_10444 : word := B#(  15,  15);	// State (3)
	D_10445 : word := B#(  0,  0);	//
	D_10446 : word := B#(  0,  0);	//
	D_10447 : int  := +00000;	//
	D_10448 : word := 2#0000000000000000;	//
	D_10449 : word := B#(  0,  0);	//
	D_10450 : word := B#(  15,  15);	// State (4)
	D_10451 : word := B#(  0,  1);	//
	D_10452 : word := B#(  3,  5);	//
	D_10453 : int  := +00000;	//
	D_10454 : word := 2#0000000000000000;	//
	D_10455 : word := B#(  0,  0);	//
	D_10456 : word := B#(  15,  15);	// State (5)
	D_10457 : word := B#(  0,  1);	//
	D_10458 : word := B#(  5,  9);	//
	D_10459 : int  := +00000;	//
	D_10460 : word := 2#0000000000000000;	//
	D_10461 : word := B#(  0,  0);	//
	D_10462 : word := B#(  15,  15);	// State (16)
	D_10463 : word := B#(  0,  1);	//
	D_10464 : word := B#(  15,  12);	//
	D_10465 : int  := +00000;	//
	D_10466 : word := 2#0000000000000000;	//
	D_10467 : word := B#(  0,  0);	//
	D_10468 : real := 0.008463541667;	//
	D_10469 : real := 2.000000000000;	//
	D_10470 : real := 0.000000000000;	//
	D_10471 : real := 1.170000000000;	//
	D_10472 : real := +0.0;	//
	D_10473 : int  := -1382;	//
	D_10474 : int  := 29030;	//
	D_10475 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_10476 : int  := 00000;	//
	D_10477 : int  := +00000;	//
	D_10478 : word  := B#(000,000);	//
	D_10479 : int  := +00000;	//
	D_10480 : real := 221.840000000000;	// Limit (1)
	D_10481 : real := +0.0;	//
	D_10482 : int  := +00000;	//
	D_10483 : word := 2#0000000000000000;	//
	D_10484 : int := +00000;	//
	D_10485 : real := 212.400000000000;	// Limit (2)
	D_10486 : real := +0.0;	//
	D_10487 : int  := +00000;	//
	D_10488 : word := 2#0000000000000000;	//
	D_10489 : int := +00000;	//
	D_10490 : real := 35.400000000000;	// Limit (3)
	D_10491 : real := +0.0;	//
	D_10492 : int  := +00000;	//
	D_10493 : word := 2#0000000000000000;	//
	D_10494 : int := +00000;	//
	D_10495 : real := 23.600000000000;	// Limit (4)
	D_10496 : real := +0.0;	//
	D_10497 : int  := +00000;	//
	D_10498 : word := 2#0000000000000000;	//
	D_10499 : int := +00000;	//
	D_10500 : word := B#(  2,  5);	//  060110 ( 02678 )
	D_10501 : word := 2#0000000000000100;	// NIVEL TANQUE DE COMBUSTIBLE 12
	D_10502 : real := +0.0;
	D_10503 : word := 2#0000000000000000;
	D_10504 : int  := +00000;
	D_10505 : int  := +00000;
	D_10506 : int  := +00000;
	D_10507 : word := B#(  0, 0);
	D_10508 : word := B#(000,000);
	D_10509 : word := 2#0000000000000000;
	D_10510 : int  := +00000;
	D_10511 : int  := +00000;
	D_10512 : word := B#(  15,  15);	// State (1)
	D_10513 : word := B#(  0,  1);	//
	D_10514 : word := B#(  13,  0);	//
	D_10515 : int  := +00000;	//
	D_10516 : word := 2#0000000000000000;	//
	D_10517 : word := B#(  0,  0);	//
	D_10518 : word := B#(  15,  15);	// State (2)
	D_10519 : word := B#(  0,  1);	//
	D_10520 : word := B#(  12,  0);	//
	D_10521 : int  := +00000;	//
	D_10522 : word := 2#0000000000000000;	//
	D_10523 : word := B#(  0,  0);	//
	D_10524 : word := B#(  15,  15);	// State (3)
	D_10525 : word := B#(  0,  0);	//
	D_10526 : word := B#(  0,  0);	//
	D_10527 : int  := +00000;	//
	D_10528 : word := 2#0000000000000000;	//
	D_10529 : word := B#(  0,  0);	//
	D_10530 : word := B#(  15,  15);	// State (4)
	D_10531 : word := B#(  0,  1);	//
	D_10532 : word := B#(  3,  5);	//
	D_10533 : int  := +00000;	//
	D_10534 : word := 2#0000000000000000;	//
	D_10535 : word := B#(  0,  0);	//
	D_10536 : word := B#(  15,  15);	// State (5)
	D_10537 : word := B#(  0,  1);	//
	D_10538 : word := B#(  5,  9);	//
	D_10539 : int  := +00000;	//
	D_10540 : word := 2#0000000000000000;	//
	D_10541 : word := B#(  0,  0);	//
	D_10542 : word := B#(  15,  15);	// State (16)
	D_10543 : word := B#(  0,  1);	//
	D_10544 : word := B#(  15,  12);	//
	D_10545 : int  := +00000;	//
	D_10546 : word := 2#0000000000000000;	//
	D_10547 : word := B#(  0,  0);	//
	D_10548 : real := 0.008463541667;	//
	D_10549 : real := 2.000000000000;	//
	D_10550 : real := 0.000000000000;	//
	D_10551 : real := 1.170000000000;	//
	D_10552 : real := +0.0;	//
	D_10553 : int  := -1382;	//
	D_10554 : int  := 29030;	//
	D_10555 : word  := B#(000,000);	//DL=Skaliergruppen-Referenz (1...N)
	D_10556 : int  := 00000;	//
	D_10557 : int  := +00000;	//
	D_10558 : word  := B#(000,000);	//
	D_10559 : int  := +00000;	//
	D_10560 : real := 221.840000000000;	// Limit (1)
	D_10561 : real := +0.0;	//
	D_10562 : int  := +00000;	//
	D_10563 : word := 2#0000000000000000;	//
	D_10564 : int := +00000;	//
	D_10565 : real := 212.400000000000;	// Limit (2)
	D_10566 : real := +0.0;	//
	D_10567 : int  := +00000;	//
	D_10568 : word := 2#0000000000000000;	//
	D_10569 : int := +00000;	//
	D_10570 : real := 35.400000000000;	// Limit (3)
	D_10571 : real := +0.0;	//
	D_10572 : int  := +00000;	//
	D_10573 : word := 2#0000000000000000;	//
	D_10574 : int := +00000;	//
	D_10575 : real := 23.600000000000;	// Limit (4)
	D_10576 : real := +0.0;	//
	D_10577 : int  := +00000;	//
	D_10578 : word := 2#0000000000000000;	//
	D_10579 : int := +00000;	//
	D_10580 : word := B#(  2,  5);	//  060111 ( 02679 )
	D_10581 : word := 2#0000000000000100;	// NIVEL TANQUE DE COMBUSTIBLE 13
	D_10582 : real := +0.0;
	D_10583 : word := 2#0000000000000000;
	D_10584 : int  := +00000;
	D_10585 : int  := +00000;
	D_10586 : int  := +00000;
	D_10587 : word := B#(  0, 0);
	D_10588 : word := B#(000,000);
	D_10589 : word := 2#0000000000000000;
	D_10590 : int  := +00000;
	D_10591 : int  := +00000;
	D_10592 : word := B#(  15,  15);	// State (1)
	D_10593 : word := B#(  0,  1);	//
	D_10594 : word := B#(  13,  0);	//
	D_10595 : int  := +00000;	//
	D_10596 : word := 2#0000000000000000;	//
	D_10597 : word := B#(  0,  0);	//
	D_10598 : word := B#(  15,  15);	// State (2)
	D_10599 : word := B#(  0,  1);	//
	D_10600 : word := B#(  12,  0);	//
	D_10601 : int  := +00000;	//
	D_10602 : word := 2#0000000000000000;	//
	D_10603 : word := B#(  0,  0);	//
	D_10604 : word := B#(  15,  15);	// State (3)
	D_10605 : word := B#(  0,  0);	//
	D_10606 : word := B#(  0,  0);	//
	D_10607 : int  := +00000;	//
	D_10608 : word := 2#0000000000000000;	//
	D_10609 : word := B#(  0,  0);	//
	D_10610 : word := B#(  15,  15);	// State (4)
	D_10611 : word := B#(  0,  1);	//
	D_10612 : word := B#(  3,  5);	//
	D_10613 : int  := +00000;	//
	D_10614 : word := 2#0000000000000000;	//
	D_10615 : word := B#(  0,  0);	//
	D_10616 : word := B#(  15,  15);	// State (5)
	D_10617 : word := B#(  0,  1);	//
	D_10618 : word := B#(  5,  9);	//
	D_10619 : int  := +00000;	//
	D_10620 : word := 2#0000000000000000;	//
	D_10621 : word := B#(  0,  0);	//
	D_10622 : word := B#(  15,  15);	// State (16)
	D_10623 : word := B#(  0,  1);	//
	D_10624 : word := B#(  15,  12);	//
	D_10625 : int  := +00000;	//
	D_10626 : word := 2#0000000000000000;	//
	D_10627 : word := B#(  0,  0);	//
	D_10628 : real := 0.008029513889;	//
	D_10629 : real := 2.0000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